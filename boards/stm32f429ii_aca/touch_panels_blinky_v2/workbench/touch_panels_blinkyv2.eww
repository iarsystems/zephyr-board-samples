<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\touch_panels_blinkyv2.ewp</path>
    </project>
    <batchBuild />
</workspace>
