# IAR project adc_dt.ewp, settings and files
configuration Default (CMake_ARM, debug)
  General.OGChipSelectEditMenu: STM32F429II ST STM32F429II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  group (top)
    ../zephyr-project/: CMakeLists.txt
  group ..__modules__hal__stm32__stm32cube [Library]/../../../../../zephyrproject/modules/hal/stm32/stm32cube/stm32f4xx/drivers/src
    ../../../../../zephyrproject/modules/hal/stm32/stm32cube/stm32f4xx/drivers/src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c
  group ..__modules__hal__stm32__stm32cube [Library]/../../../../../zephyrproject/modules/hal/stm32/stm32cube/stm32f4xx/soc
    ../../../../../zephyrproject/modules/hal/stm32/stm32cube/stm32f4xx/soc/: system_stm32f4xx.c
  group app [Library]/src
    ../zephyr-project/src/: main.c
  group arch__arm__core [Library]/../../../../../zephyrproject/zephyr-iar/arch/arm/core
    ../../../../../zephyrproject/zephyr-iar/arch/arm/core/: fatal.c nmi.c nmi_on_reset.S
  group arch__arm__core__cortex_m [Library]/../../../../../zephyrproject/zephyr-iar/arch/arm/core/cortex_m
    ../../../../../zephyrproject/zephyr-iar/arch/arm/core/cortex_m/: cpu_idle.c exc_exit.c fault.c fault_s.S fpu.c irq_init.c irq_manage.c isr_wrapper.c prep_c.c reset.S scb.c semihost.c swap_helper.S thread.c thread_abort.c vector_table.S
  group arch__arm__core__mpu [Library]/../../../../../zephyrproject/zephyr-iar/arch/arm/core/mpu
    ../../../../../zephyrproject/zephyr-iar/arch/arm/core/mpu/: arm_core_mpu.c arm_mpu.c arm_mpu_regions.c
  group arch__common [Library]/../../../../../zephyrproject/zephyr-iar/arch/common
    ../../../../../zephyrproject/zephyr-iar/arch/common/: semihost.c sw_isr_common.c
  group CMakeFiles
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/: acpi app_memory arch audio bluetooth canbus console crypto data debug devicetree dfu display drivers dsp dt-bindings fs input internal ipc kernel linker llext logging lorawan math mctp mem_mgmt mgmt misc modbus modem multi_heap net platform pm portability posix psa random retention rtio sd sensing settings shell sip_svc stats storage sys task_wdt timing toolchain tracing usb usb_c xen zbus zvfs
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/: acpi adc battery clock comparator dac dai display dma dt-util.h espi ethernet flash_controller gnss gpio i2c input inputmux interrupt-controller ipc_service led lora lvgl memory-attr memory-controller mfd mipi_dbi mipi_dsi misc pcie pinctrl power pwm qspi rdc regulator reserved-memory reset sensor spi timer usb usb-c video
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/drivers/: adc bluetooth can clock_control comparator console dac dma eeprom ethernet firmware flash gnss gpio haptics i2c i3c ieee802154 interrupt_controller led led_strip mfd mic_privacy mipi_dsi misc mm modem mspi pcie pinctrl pm_cpu_ops power pwm regulator retained_mem rtc sensor serial sip_svc spi stepper timer uart usb usb_c virtualization wifi
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/adc/: adc.h stm32_adc.h stm32f4_adc.h
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/common/: app_data_alignment.ld
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/linker/: app_smem.ld app_smem_aligned.ld app_smem_unaligned.ld common-rom
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/: arc arm arm64 common mips nios2 posix riscv sparc x86 xtensa
    ../../../../../zephyrproject/zephyr-iar/cmake/modules/: arch.cmake basic_settings.cmake boards.cmake ccache.cmake configuration_files.cmake dts.cmake extensions.cmake FindDeprecated.cmake FindDtc.cmake FindHostTools.cmake FindScaTools.cmake FindTargetTools.cmake FindZephyr-sdk.cmake generated_file_directories.cmake hwm_v2.cmake kconfig.cmake kernel.cmake pre_dt.cmake python.cmake root.cmake shields.cmake snippets.cmake soc.cmake user_cache.cmake version.cmake west.cmake yaml.cmake zephyr_default.cmake zephyr_module.cmake
    ../../../../../zephyrproject/zephyr-iar/dts/arm/: armv7-m.dtsi
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/posix/: arpa net netinet sys
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/arc/: asm-compat v2
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/bluetooth/: audio classic mesh services
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/modem/: backend
    ../../../../../zephyrproject/zephyr-iar/cmake/bintools/: bintools_template.cmake
    ../../../../../zephyrproject/zephyr-iar/boards/iar/stm32f429ii_aca/: board.cmake board.yml Kconfig.stm32f429ii_aca stm32f429ii_aca.dts stm32f429ii_aca_defconfig
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/drivers/wifi/nrf_wifi/: bus off_raw_tx
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/usb/: class
    ../../../../../zephyrproject/bootloader/mcuboot/boot/bootutil/zephyr/: CMakeLists.txt
    ../../../../../zephyrproject/modules/bsim_hw_models/nrf_hw_models/: CMakeLists.txt
    ../../../../../zephyrproject/modules/crypto/tinycrypt/: CMakeLists.txt
    ../../../../../zephyrproject/modules/debug/mipi-sys-t/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/adi/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/altera/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/ambiq/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/atmel/asf/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/atmel/asf/common/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/atmel/asf/common/components/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/atmel/asf/common/components/wifi/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/atmel/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/cmsis/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/cmsis/CMSIS/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/cmsis/CMSIS/Core/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/espressif/zephyr/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/modules/hal/intel/zephyr/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/modules/hal/libmetal/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/microchip/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/nuvoton/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/nxp/zephyr/src/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/openisa/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/quicklogic/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/renesas/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/renesas/drivers/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/renesas/zephyr/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/st/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/stm32/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/stm32/stm32cube/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/stm32/stm32cube/stm32f4xx/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/tdk/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/telink/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/modules/hal/ti/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/ti/simplelink/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/ti/simplelink/source/ti/devices/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/ti/simplelink_lpf3/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/ti/simplelink_lpf3/source/ti/boards/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/ti/simplelink_lpf3/source/ti/devices/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/wurthelektronik/: CMakeLists.txt
    ../../../../../zephyrproject/modules/hal/xtensa/: CMakeLists.txt
    ../../../../../zephyrproject/modules/lib/libmctp/zephyr/: CMakeLists.txt
    ../../../../../zephyrproject/modules/lib/open-amp/: CMakeLists.txt
    ../../../../../zephyrproject/modules/lib/picolibc/: CMakeLists.txt
    ../../../../../zephyrproject/zephyr-iar/arch/arm/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arm/core/: CMakeLists.txt Kconfig Kconfig.vfp
    ../../../../../zephyrproject/zephyr-iar/arch/arm/core/cortex_m/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arm/core/mpu/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/common/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/boards/: CMakeLists.txt deprecated.cmake Kconfig Kconfig.v2
    ../../../../../zephyrproject/zephyr-iar/boards/shields/: CMakeLists.txt
    ../../../../../zephyrproject/zephyr-iar/cmake/flash/: CMakeLists.txt
    ../../../../../zephyrproject/zephyr-iar/cmake/reports/: CMakeLists.txt
    ../../../../../zephyrproject/zephyr-iar/cmake/usage/: CMakeLists.txt
    ../../../../../zephyrproject/zephyr-iar/: CMakeLists.txt include Kconfig Kconfig.constants Kconfig.zephyr VERSION
    ../../../../../zephyrproject/zephyr-iar/drivers/adc/: CMakeLists.txt Kconfig Kconfig.ad405x Kconfig.ad4114 Kconfig.ad4130 Kconfig.ad559x Kconfig.ad7124 Kconfig.adc_emul Kconfig.ads1112 Kconfig.ads1119 Kconfig.ads131m02 Kconfig.ads1x1x Kconfig.ads1x4s0x Kconfig.ads7052 Kconfig.ambiq Kconfig.b91 Kconfig.cc13xx_cc26xx Kconfig.cc32xx Kconfig.ene Kconfig.esp32 Kconfig.gd32 Kconfig.gecko Kconfig.ifx_cat1 Kconfig.it8xxx2 Kconfig.lmp90xxx Kconfig.ltc2451 Kconfig.max11102_17 Kconfig.max1125x Kconfig.max32 Kconfig.mcp320x Kconfig.mcux Kconfig.npcx Kconfig.nrfx Kconfig.numaker Kconfig.nxp_s32 Kconfig.renesas_ra Kconfig.renesas_rz Kconfig.rpi_pico Kconfig.sam Kconfig.sam0 Kconfig.sam_afec Kconfig.smartbond Kconfig.stm32 Kconfig.test Kconfig.tla202x Kconfig.vf610 Kconfig.xec Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/clock_control/: CMakeLists.txt Kconfig Kconfig.agilex5 Kconfig.ambiq Kconfig.arm_scmi Kconfig.aspeed Kconfig.beetle Kconfig.cavs Kconfig.esp32 Kconfig.fixed Kconfig.gd32 Kconfig.ifx_cat1 Kconfig.it51xxx Kconfig.litex Kconfig.lpc11u6x Kconfig.max32 Kconfig.mcux_ccm Kconfig.mcux_ccm_rev2 Kconfig.mcux_mcg Kconfig.mcux_pcc Kconfig.mcux_scg Kconfig.mcux_sim Kconfig.mcux_syscon Kconfig.npcm Kconfig.npcx Kconfig.nrf Kconfig.nrf_auxpll Kconfig.numaker Kconfig.nxp_s32 Kconfig.pwm Kconfig.rcar Kconfig.renesas_ra_cgc Kconfig.renesas_rz_cpg Kconfig.rpi_pico Kconfig.rts5912 Kconfig.rv32m1 Kconfig.sam Kconfig.si32 Kconfig.silabs Kconfig.siwx91x Kconfig.smartbond Kconfig.stm32 Kconfig.wch_rcc Kconfig.xec
    ../../../../../zephyrproject/zephyr-iar/drivers/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/console/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/disk/: CMakeLists.txt Kconfig Kconfig.flash Kconfig.loopback Kconfig.mmc Kconfig.ram Kconfig.sdmmc
    ../../../../../zephyrproject/zephyr-iar/drivers/firmware/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/gpio/: CMakeLists.txt Kconfig Kconfig.ad559x Kconfig.adp5585 Kconfig.ads1x4s0x Kconfig.altera Kconfig.ambiq Kconfig.andes_atcgpio100 Kconfig.aw9523b Kconfig.axp192 Kconfig.b91 Kconfig.bcm2711 Kconfig.bd8lb600fs Kconfig.brcmstb Kconfig.cc13xx_cc26xx Kconfig.cc23x0 Kconfig.cc32xx Kconfig.cmsdk_ahb Kconfig.creg_gpio Kconfig.cy8c95xx Kconfig.davinci Kconfig.dw Kconfig.efinix_sapphire Kconfig.emul Kconfig.emul_sdl Kconfig.ene Kconfig.eos_s3 Kconfig.esp32 Kconfig.fxl6408 Kconfig.gd32 Kconfig.gecko Kconfig.grgpio Kconfig.ifx_cat1 Kconfig.imx Kconfig.intel Kconfig.iproc Kconfig.it51xxx Kconfig.it8801 Kconfig.it8xxx2 Kconfig.litex Kconfig.lmp90xxx Kconfig.lpc11u6x Kconfig.max14906 Kconfig.max14916 Kconfig.max14917 Kconfig.max22017 Kconfig.max2219x Kconfig.max32 Kconfig.mchp_mss Kconfig.mcp23xxx Kconfig.mcux Kconfig.mcux_igpio Kconfig.mcux_lpc Kconfig.mcux_rgpio Kconfig.mec5 Kconfig.mfxstm32l152 Kconfig.mmio32 Kconfig.nct38xx Kconfig.neorv32 Kconfig.npcx Kconfig.npm1300 Kconfig.npm2100 Kconfig.npm6001 Kconfig.nrfx Kconfig.numaker Kconfig.numicro Kconfig.nxp_s32 Kconfig.pca6416 Kconfig.pca953x Kconfig.pca95xx Kconfig.pca_series Kconfig.pcal64xxa Kconfig.pcf857x Kconfig.psoc6 Kconfig.rcar Kconfig.renesas_ra_ioport Kconfig.renesas_rz Kconfig.rp1 Kconfig.rpi_pico Kconfig.rt1718s Kconfig.rts5912 Kconfig.rv32m1 Kconfig.rzt2m Kconfig.sam Kconfig.sam0 Kconfig.sc18im704 Kconfig.sedi Kconfig.si32 Kconfig.sifive Kconfig.siwx91x Kconfig.smartbond Kconfig.sn74hc595 Kconfig.stellaris Kconfig.stm32 Kconfig.stmpe1600 Kconfig.sx1509b Kconfig.sy1xx Kconfig.tca6424a Kconfig.test Kconfig.tle9104 Kconfig.wch_ch32v00x Kconfig.xec Kconfig.xlnx Kconfig.xlnx_ps Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/interrupt_controller/: CMakeLists.txt Kconfig Kconfig.cavs Kconfig.clic Kconfig.dw Kconfig.esp32 Kconfig.gd32_exti Kconfig.gic Kconfig.intel_vtd Kconfig.it51xxx Kconfig.it8xxx2 Kconfig.loapic Kconfig.mtk_adsp Kconfig.multilevel Kconfig.multilevel.aggregator_template Kconfig.npcx Kconfig.nxp_irqsteer Kconfig.nxp_pint Kconfig.nxp_s32 Kconfig.plic Kconfig.renesas_rz Kconfig.rv32m1 Kconfig.sam0 Kconfig.shared_irq Kconfig.stm32 Kconfig.vim Kconfig.wch_pfic Kconfig.xec Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/coresight/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/pcie/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/pinctrl/: CMakeLists.txt Kconfig Kconfig.ambiq Kconfig.arm_mps2 Kconfig.arm_mps3 Kconfig.arm_v2m_beetle Kconfig.b91 Kconfig.cc13xx_cc26xx Kconfig.cc23x0 Kconfig.emsdp Kconfig.ene Kconfig.eos_s3 Kconfig.esp32 Kconfig.gd32 Kconfig.gecko Kconfig.ifx_cat1 Kconfig.imx Kconfig.it8xxx2 Kconfig.lpc_iocon Kconfig.max32 Kconfig.mci_io_mux Kconfig.mec5 Kconfig.npcx Kconfig.nrf Kconfig.numaker Kconfig.numicro Kconfig.nxp_port Kconfig.nxp_s32 Kconfig.realtek_rts5912 Kconfig.rpi_pico Kconfig.rv32m1 Kconfig.sam Kconfig.sam0 Kconfig.sifive Kconfig.silabs_dbus Kconfig.siwx91x Kconfig.stm32 Kconfig.sy1xx Kconfig.ti_cc32xx Kconfig.ti_k3 Kconfig.wch_20x_30x_afio Kconfig.wch_afio Kconfig.xec Kconfig.xlnx Kconfig.xmc4xxx Kconfig.zynqmp
    ../../../../../zephyrproject/zephyr-iar/drivers/pinctrl/renesas/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/timer/: CMakeLists.txt Kconfig Kconfig.altera_avalon Kconfig.ambiq Kconfig.arcv2 Kconfig.arm_arch Kconfig.cavs Kconfig.cc13xx_cc26xx_rtc Kconfig.cc23x0_systim Kconfig.cortex_m_systick Kconfig.esp32 Kconfig.gecko Kconfig.it51xxx Kconfig.ite_it8xxx2 Kconfig.leon_gptimer Kconfig.litex Kconfig.mchp_xec_rtos Kconfig.mcux_gpt Kconfig.mcux_lptmr Kconfig.mcux_os Kconfig.mec5 Kconfig.mips_cp0 Kconfig.mtk_adsp Kconfig.native_sim Kconfig.npcx_itim Kconfig.nrf_grtc Kconfig.nrf_rtc Kconfig.nrf_xrtc Kconfig.rcar_cmt Kconfig.realtek_rts5912_rtmr Kconfig.renesas_ra_ulpt Kconfig.riscv_machine Kconfig.rv32m1_lptmr Kconfig.sam0_rtc Kconfig.silabs Kconfig.smartbond Kconfig.stm32_lptim Kconfig.sy1xx_sys_timer Kconfig.ti_dm_timer Kconfig.wch_ch32v00x Kconfig.x86 Kconfig.xlnx_psttc Kconfig.xtensa
    ../../../../../zephyrproject/zephyr-iar/drivers/usb/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/usb/common/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/usb_c/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/kernel/: CMakeLists.txt Kconfig Kconfig.device Kconfig.init Kconfig.mem_domain Kconfig.obj_core Kconfig.smp Kconfig.vm
    ../../../../../zephyrproject/zephyr-iar/lib/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/crc/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/hash/: CMakeLists.txt Kconfig Kconfig.hash_func Kconfig.hash_map
    ../../../../../zephyrproject/zephyr-iar/lib/heap/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/libc/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/libc/common/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/mem_blocks/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/os/: CMakeLists.txt Kconfig Kconfig.cbprintf
    ../../../../../zephyrproject/zephyr-iar/lib/posix/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/posix/options/: CMakeLists.txt Kconfig Kconfig.aio Kconfig.barrier Kconfig.c_lang_r Kconfig.c_lib_ext Kconfig.compat Kconfig.device_io Kconfig.fd_mgmt Kconfig.file_system_r Kconfig.fs Kconfig.mem Kconfig.mqueue Kconfig.net Kconfig.proc1 Kconfig.procN Kconfig.profile Kconfig.pthread Kconfig.rwlock Kconfig.sched Kconfig.semaphore Kconfig.signal Kconfig.spinlock Kconfig.sync_io Kconfig.timer Kconfig.toolchain Kconfig.xsi_realtime Kconfig.xsi_single_process Kconfig.xsi_streams Kconfig.xsi_system_logging Kconfig.xsi_threads_ext
    ../../../../../zephyrproject/zephyr-iar/lib/utils/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/uuid/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/misc/generated/: CMakeLists.txt configs.c.in
    ../../../../../zephyrproject/zephyr-iar/modules/acpica/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/cmsis-dsp/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/cmsis-nn/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/cmsis/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/fatfs/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_ethos_u/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_gigadevice/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_infineon/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_nordic/: CMakeLists.txt Kconfig Kconfig.nrf_regtool
    ../../../../../zephyrproject/zephyr-iar/modules/hal_nxp/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_rpi_pico/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_silabs/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_wch/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hostap/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/liblc3/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/littlefs/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/loramac-node/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/lvgl/: CMakeLists.txt Kconfig Kconfig.input Kconfig.memory Kconfig.shell
    ../../../../../zephyrproject/zephyr-iar/modules/mbedtls/: CMakeLists.txt Kconfig Kconfig.mbedtls Kconfig.psa.auto Kconfig.psa.logic
    ../../../../../zephyrproject/zephyr-iar/modules/nrf_wifi/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/openthread/: CMakeLists.txt Kconfig Kconfig.features Kconfig.thread
    ../../../../../zephyrproject/zephyr-iar/modules/percepio/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/segger/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/trusted-firmware-a/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/trusted-firmware-m/: CMakeLists.txt Kconfig Kconfig.tfm Kconfig.tfm.crypto_modules Kconfig.tfm.partitions
    ../../../../../zephyrproject/zephyr-iar/modules/uoscore-uedhoc/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/zcbor/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/soc/: CMakeLists.txt Kconfig Kconfig.v2
    ../../../../../zephyrproject/zephyr-iar/soc/common/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/: CMakeLists.txt Kconfig Kconfig.defconfig Kconfig.soc soc.yml
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/common/: CMakeLists.txt
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32f4x/: CMakeLists.txt Kconfig Kconfig.defconfig Kconfig.defconfig.stm32f401xc Kconfig.defconfig.stm32f401xe Kconfig.defconfig.stm32f405xx Kconfig.defconfig.stm32f407xx Kconfig.defconfig.stm32f410xx Kconfig.defconfig.stm32f411xe Kconfig.defconfig.stm32f412rx Kconfig.defconfig.stm32f412xx Kconfig.defconfig.stm32f413xx Kconfig.defconfig.stm32f415xx Kconfig.defconfig.stm32f417xx Kconfig.defconfig.stm32f423xx Kconfig.defconfig.stm32f427xx Kconfig.defconfig.stm32f429xx Kconfig.defconfig.stm32f437xx Kconfig.defconfig.stm32f439xx Kconfig.defconfig.stm32f446xx Kconfig.defconfig.stm32f469xx Kconfig.defconfig.stm32f479xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/subsys/canbus/: CMakeLists.txt Kconfig Kconfig.canopen
    ../../../../../zephyrproject/zephyr-iar/subsys/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/debug/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/fb/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/fs/: CMakeLists.txt Kconfig Kconfig.fatfs Kconfig.littlefs
    ../../../../../zephyrproject/zephyr-iar/subsys/ipc/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/logging/backends/: CMakeLists.txt Kconfig Kconfig.adsp Kconfig.adsp_mtrace Kconfig.ble Kconfig.efi_console Kconfig.fs Kconfig.multidomain Kconfig.native_posix Kconfig.net Kconfig.rtt Kconfig.semihost Kconfig.spinel Kconfig.swo Kconfig.uart Kconfig.ws Kconfig.xtensa_sim
    ../../../../../zephyrproject/zephyr-iar/subsys/logging/: CMakeLists.txt Kconfig Kconfig.filtering Kconfig.formatting Kconfig.links Kconfig.misc Kconfig.mode Kconfig.processing Kconfig.template.log_config Kconfig.template.log_config_inherit Kconfig.template.log_format_config
    ../../../../../zephyrproject/zephyr-iar/subsys/logging/frontends/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mem_mgmt/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/modbus/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/pm/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/pm/policy/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/portability/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/random/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/rtio/: CMakeLists.txt Kconfig Kconfig.workq
    ../../../../../zephyrproject/zephyr-iar/subsys/sd/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/stats/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/storage/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/task_wdt/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/testsuite/: CMakeLists.txt Kconfig Kconfig.defconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/tracing/: CMakeLists.txt Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/: CMakeLists.txt
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/riscv/: common riscv-privileged
    ../../../../../zephyrproject/zephyr-iar/cmake/linker_script/common/: common-ram.cmake common-rom.cmake debug-sections.cmake kobject-data.cmake kobject-rom.cmake kobject-text.cmake ram-end.cmake thread-local-storage.cmake
    ../../../../../zephyrproject/zephyr-iar/cmake/compiler/: compiler_features.cmake compiler_flags_template.cmake
    ../../../../../zephyrproject/zephyr-iar/cmake/compiler/iar/: compiler_flags.cmake generic.cmake iccarm-cpu.cmake iccarm-fpu.cmake target.cmake
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/net/: conn_mgr hdlc_rcp_if http prometheus
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/debug/: coresight
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/drivers/misc/: coresight devmux ft8xx grove_lcd nxp_flexio pio_rpi_pico renesas_ra_external_interrupt stm32_wkup_pins timeaware_gpio
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/arm/: cortex_a_r cortex_m cortex_r mmu mpu
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/arm64/: cortex_r scripts
    ../../../../../zephyrproject/zephyr-iar/boards/common/: cspy.board.cmake jlink.board.cmake openocd-stm32.board.cmake openocd.board.cmake pyocd.board.cmake
    ../../../../../zephyrproject/zephyr-iar/boards/shields/esp_8266/boards/: disco_l475_iot1.defconfig sam4e_xpro.defconfig
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/xen/: dom0 public
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/arc/v2/: dsp mpu secureshield vpx
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/mgmt/: ec_host_cmd hawkbit mcumgr
    ../../../../../zephyrproject/zephyr-iar/misc/: empty_file.c
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/drivers/pcie/: endpoint
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/mgmt/mcumgr/grp/: enum_mgmt fs_mgmt img_mgmt os_mgmt settings_mgmt shell_mgmt stat_mgmt zephyr
    ../../../../../zephyrproject/zephyr-iar/cmake/: extra_flags.cmake gcc-m-cpu.cmake gcc-m-fpu.cmake kobj.cmake target_toolchain_flags.cmake
    ../../../../../zephyrproject/zephyr-iar/boards/shields/frdm_cr20a/boards/: frdm_k64f.defconfig
    ../../../../../zephyrproject/zephyr-iar/boards/shields/inventek_eswifi/boards/: frdm_k64f.defconfig nucleo_f767zi.defconfig
    ../../../../../zephyrproject/zephyr-iar/dts/common/: freq.h mem.h skeleton.dtsi
    ../../../../../zephyrproject/zephyr-iar/scripts/dts/: gen_defines.py gen_driver_kconfig_dts.py gen_dts_cmake.py gen_edt.py
    ../../../../../zephyrproject/zephyr-iar/cmake/toolchain/iar/: generic.cmake Kconfig Kconfig.defconfig target.cmake
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/gpio/: gpio.h
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/mgmt/mcumgr/: grp mgmt smp transport
    ../../../../../../progs/zephyr-sdk-0.17.0/cmake/zephyr/: host-tools.cmake
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/xen/public/: hvm io
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/i2c/: i2c.h
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/x86/: ia32 intel64
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/toolchain/: iar
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/input/: input-event-codes.h
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/drivers/mic_privacy/: intel
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/kernel/: internal mm
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/sys/: internal util_internal.h util_internal_is_eq.h util_internal_util_dec.h util_internal_util_inc.h util_internal_util_x2.h util_listify.h util_loops.h util_macro.h
    ../../../../../zephyrproject/modules/debug/percepio/DFM/kernelports/Zephyr/: Kconfig
    ../../../../../zephyrproject/modules/debug/percepio/DFM/kernelports/Zephyr/storageports/Filesystem/: Kconfig
    ../../../../../zephyrproject/modules/debug/percepio/DFM/kernelports/Zephyr/storageports/Flash/: Kconfig
    ../../../../../zephyrproject/modules/debug/percepio/TraceRecorder/config/: Kconfig
    ../../../../../zephyrproject/modules/debug/percepio/TraceRecorder/kernelports/Zephyr/: Kconfig
    ../../../../../zephyrproject/modules/debug/percepio/TraceRecorder/kernelports/Zephyr/streamports/Semihost/: Kconfig
    ../../../../../zephyrproject/modules/debug/percepio/TraceRecorder/streamports/ARM_ITM/: Kconfig
    ../../../../../zephyrproject/modules/debug/percepio/TraceRecorder/streamports/File/: Kconfig
    ../../../../../zephyrproject/modules/debug/percepio/TraceRecorder/streamports/Jlink_RTT/: Kconfig
    ../../../../../zephyrproject/modules/debug/percepio/TraceRecorder/streamports/RingBuffer/: Kconfig
    ../../../../../zephyrproject/modules/debug/percepio/zephyr/: Kconfig
    ../../../../../zephyrproject/modules/hal/telink/tlsr9/: Kconfig
    ../../../../../zephyrproject/modules/lib/gui/lvgl/: Kconfig
    ../../../../../zephyrproject/modules/lib/gui/lvgl/zephyr/: Kconfig
    ../../../../../zephyrproject/modules/lib/picolibc/zephyr/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arc/core/dsp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arc/core/mpu/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arc/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arm64/core/cortex_r/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arm64/core/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arm64/core/xen/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arm64/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arm/core/cortex_a_r/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arm/core/cortex_m/tz/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/arm/core/mmu/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/mips/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/nios2/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/posix/: Kconfig Kconfig.natsim_optional
    ../../../../../zephyrproject/zephyr-iar/arch/riscv/: Kconfig Kconfig.isa
    ../../../../../zephyrproject/zephyr-iar/arch/sparc/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/x86/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/arch/xtensa/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/audio/: Kconfig Kconfig.cs43l22 Kconfig.dmic_mcux Kconfig.dmic_pdm_nrfx Kconfig.mpxxdtyy Kconfig.tas6422dac Kconfig.tlv320aic3110 Kconfig.tlv320dac Kconfig.wm8904
    ../../../../../zephyrproject/zephyr-iar/drivers/auxdisplay/: Kconfig Kconfig.hd44780 Kconfig.itron Kconfig.jhd1313 Kconfig.pt6314 Kconfig.serlcd
    ../../../../../zephyrproject/zephyr-iar/drivers/bbram/: Kconfig Kconfig.bbram_emul Kconfig.it8xxx2 Kconfig.microchip Kconfig.npcx Kconfig.rts5912 Kconfig.stm32 Kconfig.xec
    ../../../../../zephyrproject/zephyr-iar/drivers/bluetooth/hci/: Kconfig Kconfig.esp32 Kconfig.infineon Kconfig.nxp Kconfig.silabs
    ../../../../../zephyrproject/zephyr-iar/drivers/bluetooth/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/cache/: Kconfig Kconfig.andes Kconfig.aspeed Kconfig.nrf Kconfig.nxp_xcache
    ../../../../../zephyrproject/zephyr-iar/drivers/can/: Kconfig Kconfig.esp32 Kconfig.fake Kconfig.kvaser Kconfig.loopback Kconfig.mcan Kconfig.mcp2515 Kconfig.mcp251xfd Kconfig.mcux Kconfig.native_linux Kconfig.nrf Kconfig.numaker Kconfig.nxp_s32 Kconfig.rcar Kconfig.renesas_ra Kconfig.sam Kconfig.sam0 Kconfig.sja1000 Kconfig.stm32 Kconfig.tcan4x5x Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/can/transceiver/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/charger/: Kconfig Kconfig.bq24190 Kconfig.bq25180 Kconfig.bq25713 Kconfig.max20335 Kconfig.pf1550 Kconfig.sbs_charger
    ../../../../../zephyrproject/zephyr-iar/drivers/comparator/: Kconfig Kconfig.fake_comp Kconfig.mcux_acmp Kconfig.nrf_comp Kconfig.nrf_lpcomp Kconfig.renesas_ra Kconfig.shell Kconfig.silabs_acmp
    ../../../../../zephyrproject/zephyr-iar/drivers/coredump/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/counter/: Kconfig Kconfig.ace Kconfig.ambiq Kconfig.andes_atcpit100 Kconfig.cmos Kconfig.dtmr_cmsdk_apb Kconfig.dw Kconfig.esp32_rtc Kconfig.esp32_tmr Kconfig.gd32 Kconfig.gecko Kconfig.ifx_cat1 Kconfig.imx_epit Kconfig.ite_it8xxx2 Kconfig.max32_rtc Kconfig.max32_timer Kconfig.maxim_ds3231 Kconfig.mcp7940n Kconfig.mcux_ctimer Kconfig.mcux_gpt Kconfig.mcux_lpc_rtc Kconfig.mcux_lptmr Kconfig.mcux_qtmr Kconfig.mcux_rtc Kconfig.mcux_snvs Kconfig.mcux_tpm Kconfig.native_sim Kconfig.nrfx Kconfig.nxp_mrt Kconfig.nxp_pit Kconfig.nxp_s32 Kconfig.renesas_ra Kconfig.renesas_rz Kconfig.rpi_pico Kconfig.rts5912_slwtmr Kconfig.sam Kconfig.sam0 Kconfig.smartbond_timer Kconfig.stm32_rtc Kconfig.stm32_timer Kconfig.tmr_cmsdk_apb Kconfig.xec Kconfig.xlnx
    ../../../../../zephyrproject/zephyr-iar/drivers/crypto/: Kconfig Kconfig.ataes132a Kconfig.cc23x0 Kconfig.intel Kconfig.it8xxx2 Kconfig.mcux_dcp Kconfig.npcx Kconfig.nrf_ecb Kconfig.si32 Kconfig.smartbond Kconfig.stm32 Kconfig.xec
    ../../../../../zephyrproject/zephyr-iar/drivers/dac/: Kconfig Kconfig.ad559x Kconfig.ad569x Kconfig.ad56xx Kconfig.dac161s997 Kconfig.dacx0501 Kconfig.dacx0508 Kconfig.dacx3608 Kconfig.esp32 Kconfig.gd32 Kconfig.ltc166x Kconfig.max22017 Kconfig.mcp4725 Kconfig.mcp4728 Kconfig.mcux Kconfig.renesas_ra Kconfig.sam Kconfig.sam0 Kconfig.stm32 Kconfig.test
    ../../../../../zephyrproject/zephyr-iar/drivers/dai/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/disk/nvme/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/display/: Kconfig Kconfig.dummy Kconfig.gc9x01x Kconfig.hx8394 Kconfig.ili9806e_dsi Kconfig.ili9xxx Kconfig.intel_multibootfb Kconfig.ist3931 Kconfig.led_strip_matrix Kconfig.ls0xx Kconfig.max7219 Kconfig.mcux_dcnano_lcdif Kconfig.mcux_elcdif Kconfig.microbit Kconfig.nrf_led_matrix Kconfig.nt35510 Kconfig.otm8009a Kconfig.renesas_lcdc Kconfig.renesas_ra Kconfig.rm67162 Kconfig.rm68200 Kconfig.sdl Kconfig.ssd1306 Kconfig.ssd1322 Kconfig.ssd1327 Kconfig.ssd16xx Kconfig.st7567 Kconfig.st7701 Kconfig.st7735r Kconfig.st7789v Kconfig.st7796s Kconfig.stm32_ltdc Kconfig.uc81xx
    ../../../../../zephyrproject/zephyr-iar/drivers/dma/: Kconfig Kconfig.andes_atcdmac300 Kconfig.dma_pl330 Kconfig.dw Kconfig.dw_axi_dmac Kconfig.dw_common Kconfig.emul Kconfig.esp32 Kconfig.gd32 Kconfig.ifx_cat1 Kconfig.intel_adsp_gpdma Kconfig.intel_adsp_hda Kconfig.intel_lpss Kconfig.iproc_pax Kconfig.max32 Kconfig.mcux_edma Kconfig.mcux_lpc Kconfig.mcux_pxp Kconfig.mcux_smartdma Kconfig.nios2_msgdma Kconfig.nxp_edma Kconfig.nxp_sdma Kconfig.nxp_sof_host_dma Kconfig.renesas_rz Kconfig.rpi_pico Kconfig.sam0 Kconfig.sam_xdmac Kconfig.sedi Kconfig.si32 Kconfig.silabs Kconfig.siwx91x Kconfig.smartbond Kconfig.stm32 Kconfig.ti_cc23x0 Kconfig.wch Kconfig.xec Kconfig.xilinx_axi_dma Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/dp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/edac/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/eeprom/: Kconfig Kconfig.eeprom_emu Kconfig.lpc11u6x Kconfig.mb85rcxx Kconfig.mb85rsxx Kconfig.stm32 Kconfig.tmp11x Kconfig.xec
    ../../../../../zephyrproject/zephyr-iar/drivers/entropy/: Kconfig Kconfig.b91 Kconfig.bt_hci Kconfig.cc13xx_cc26xx Kconfig.esp32 Kconfig.gecko Kconfig.litex Kconfig.max32 Kconfig.maxq10xx Kconfig.mcux Kconfig.native_sim Kconfig.neorv32 Kconfig.npcx Kconfig.nrf5 Kconfig.nrf_cracen Kconfig.nxp Kconfig.psa_crypto Kconfig.renesas_ra Kconfig.rv32m1 Kconfig.sam Kconfig.siwx91x Kconfig.smartbond Kconfig.stm32 Kconfig.sy1xx
    ../../../../../zephyrproject/zephyr-iar/drivers/espi/: Kconfig Kconfig.espi_emul Kconfig.it8xxx2 Kconfig.npcx Kconfig.xec
    ../../../../../zephyrproject/zephyr-iar/drivers/ethernet/dsa/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/ethernet/dwc_xgmac/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/ethernet/eth_nxp_enet_qos/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/ethernet/: Kconfig Kconfig.adin2111 Kconfig.cyclonev Kconfig.dwmac Kconfig.e1000 Kconfig.enc28j60 Kconfig.enc424j600 Kconfig.esp32 Kconfig.gecko Kconfig.ivshmem Kconfig.lan865x Kconfig.lan9250 Kconfig.litex Kconfig.native_tap Kconfig.numaker Kconfig.nxp_enet Kconfig.nxp_s32_gmac Kconfig.nxp_s32_netc Kconfig.renesas_ra Kconfig.sam_gmac Kconfig.smsc911x Kconfig.smsc91x Kconfig.stellaris Kconfig.stm32_hal Kconfig.sy1xx_mac Kconfig.test Kconfig.w5500 Kconfig.xilinx_axienet Kconfig.xlnx_gem Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/ethernet/nxp_imx_netc/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/ethernet/phy/: Kconfig Kconfig.dm8806 Kconfig.microchip_t1s Kconfig.tja1103
    ../../../../../zephyrproject/zephyr-iar/drivers/firmware/scmi/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/firmware/scmi/nxp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/flash/: Kconfig Kconfig.ambiq Kconfig.andes Kconfig.at45 Kconfig.b91 Kconfig.cadence_nand Kconfig.cadence_qspi_nor Kconfig.cc13xx_cc26xx Kconfig.cc23x0 Kconfig.esp32 Kconfig.gd32 Kconfig.gecko Kconfig.ifx_cat1 Kconfig.it8xxx2 Kconfig.lpc Kconfig.max32 Kconfig.mcux Kconfig.mspi Kconfig.nios2_qspi Kconfig.nor Kconfig.nordic_qspi_nor Kconfig.npcx_fiu Kconfig.nrf Kconfig.nrf_mram Kconfig.nrf_rram Kconfig.numaker Kconfig.numaker_rmc Kconfig.nxp_s32 Kconfig.renesas_ra Kconfig.rpi_pico Kconfig.rv32m1 Kconfig.sam Kconfig.sam0 Kconfig.si32 Kconfig.silabs Kconfig.simulator Kconfig.siwx91x Kconfig.smartbond Kconfig.stm32 Kconfig.stm32_ospi Kconfig.stm32_qspi Kconfig.stm32_xspi Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/fpga/: Kconfig Kconfig.altera_agilex_bridge Kconfig.eos_s3 Kconfig.ice40 Kconfig.mpfs Kconfig.slg471x5 Kconfig.zynqmp
    ../../../../../zephyrproject/zephyr-iar/drivers/fuel_gauge/bq27z746/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/fuel_gauge/composite/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/fuel_gauge/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/fuel_gauge/max17048/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/fuel_gauge/sbs_gauge/: Kconfig Kconfig.emul_sbs_gauge
    ../../../../../zephyrproject/zephyr-iar/drivers/gnss/: Kconfig Kconfig.emul Kconfig.generic Kconfig.luatos_air530z Kconfig.quectel_lcx6g Kconfig.u_blox_m8
    ../../../../../zephyrproject/zephyr-iar/drivers/haptics/: Kconfig Kconfig.drv2605
    ../../../../../zephyrproject/zephyr-iar/drivers/hdlc_rcp_if/: Kconfig Kconfig.nxp Kconfig.uart
    ../../../../../zephyrproject/zephyr-iar/drivers/hwinfo/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/hwspinlock/: Kconfig Kconfig.sqn
    ../../../../../zephyrproject/zephyr-iar/drivers/i2c/: Kconfig Kconfig.ambiq Kconfig.andes_atciic100 Kconfig.b91 Kconfig.bcm_iproc Kconfig.cc13xx_cc26xx Kconfig.cdns Kconfig.dw Kconfig.ene Kconfig.esp32 Kconfig.gd32 Kconfig.gpio Kconfig.i2c_emul Kconfig.ifx_cat1 Kconfig.ifx_xmc4 Kconfig.it8xxx2 Kconfig.litex Kconfig.lpc11u6x Kconfig.max32 Kconfig.mchp_mss Kconfig.mcux Kconfig.npcx Kconfig.nrfx Kconfig.numaker Kconfig.omap Kconfig.rcar Kconfig.renesas_ra Kconfig.renesas_rz Kconfig.sam0 Kconfig.sam_twihs Kconfig.sbcon Kconfig.sc18im704 Kconfig.sedi Kconfig.sifive Kconfig.smartbond Kconfig.stm32 Kconfig.sy1xx Kconfig.tca954x Kconfig.test Kconfig.xec Kconfig.xilinx_axi
    ../../../../../zephyrproject/zephyr-iar/drivers/i2c/target/: Kconfig Kconfig.eeprom
    ../../../../../zephyrproject/zephyr-iar/drivers/i2s/: Kconfig Kconfig.esp32 Kconfig.litex Kconfig.mcux Kconfig.mcux_flexcomm Kconfig.nrfx Kconfig.sam_ssc Kconfig.stm32 Kconfig.test
    ../../../../../zephyrproject/zephyr-iar/drivers/i3c/: Kconfig Kconfig.cdns Kconfig.dw Kconfig.npcx Kconfig.nxp Kconfig.stm32 Kconfig.test
    ../../../../../zephyrproject/zephyr-iar/drivers/ieee802154/: Kconfig Kconfig.b91 Kconfig.cc1200 Kconfig.cc13xx_cc26xx Kconfig.cc2520 Kconfig.dw1000 Kconfig.kw41z Kconfig.mcr20a Kconfig.mcxw Kconfig.nrf5 Kconfig.rf2xx Kconfig.uart_pipe
    ../../../../../zephyrproject/zephyr-iar/drivers/input/: Kconfig Kconfig.adc_keys Kconfig.analog_axis Kconfig.cap12xx Kconfig.cf1133 Kconfig.chsc6x Kconfig.cst816s Kconfig.cy8cmbr3xxx Kconfig.esp32 Kconfig.evdev Kconfig.ft5336 Kconfig.gpio_kbd_matrix Kconfig.gpio_keys Kconfig.gpio_qdec Kconfig.gt911 Kconfig.ili2132a Kconfig.it51xxx Kconfig.it8801 Kconfig.it8xxx2 Kconfig.kbd_matrix Kconfig.npcx Kconfig.nunchuk Kconfig.pat912x Kconfig.paw32xx Kconfig.pinnacle Kconfig.pmw3610 Kconfig.rts5912 Kconfig.sbus Kconfig.sdl Kconfig.stmpe811 Kconfig.touch Kconfig.tsc_keys Kconfig.xec Kconfig.xpt2046
    ../../../../../zephyrproject/zephyr-iar/drivers/ipm/: Kconfig Kconfig.imx Kconfig.intel_adsp Kconfig.ivshmem Kconfig.nrfx Kconfig.nrfx_ipc_channel Kconfig.sedi Kconfig.stm32
    ../../../../../zephyrproject/zephyr-iar/drivers/led/: Kconfig Kconfig.gpio Kconfig.ht16k33 Kconfig.is31fl3194 Kconfig.is31fl3216a Kconfig.is31fl3733 Kconfig.lp3943 Kconfig.lp50xx Kconfig.lp5562 Kconfig.lp5569 Kconfig.ncp5623 Kconfig.npm1300 Kconfig.pca9633 Kconfig.pwm Kconfig.tlc59108 Kconfig.xec
    ../../../../../zephyrproject/zephyr-iar/drivers/led_strip/: Kconfig Kconfig.apa102 Kconfig.lpd880x Kconfig.tlc5971 Kconfig.tlc59731 Kconfig.ws2812
    ../../../../../zephyrproject/zephyr-iar/drivers/lora/: Kconfig Kconfig.rylrxxx Kconfig.sx12xx
    ../../../../../zephyrproject/zephyr-iar/drivers/mbox/: Kconfig Kconfig.andes Kconfig.esp32 Kconfig.ivshmem Kconfig.mhuv3 Kconfig.nrf_bellboard Kconfig.nrf_vevif_event Kconfig.nrf_vevif_task Kconfig.nrfx Kconfig.nxp_imx Kconfig.nxp_mailbox Kconfig.nxp_s32 Kconfig.renesas_rz Kconfig.stm32_hsem Kconfig.ti_omap
    ../../../../../zephyrproject/zephyr-iar/drivers/mdio/: Kconfig Kconfig.adin2111 Kconfig.dwcxgmac Kconfig.esp32 Kconfig.gpio Kconfig.lan865x Kconfig.litex Kconfig.nxp_enet Kconfig.nxp_enet_qos Kconfig.nxp_imx_netc Kconfig.nxp_s32_gmac Kconfig.nxp_s32_netc Kconfig.renesas_ra Kconfig.sam Kconfig.stm32_hal Kconfig.sy1xx Kconfig.xilinx_axienet Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/memc/: Kconfig Kconfig.mcux Kconfig.mspi Kconfig.nxp_s32 Kconfig.renesas_ra Kconfig.sam Kconfig.sifive Kconfig.smartbond Kconfig.stm32
    ../../../../../zephyrproject/zephyr-iar/drivers/mfd/: Kconfig Kconfig.ad559x Kconfig.adp5585 Kconfig.aw9523b Kconfig.axp192 Kconfig.bd8lb600fs Kconfig.ds3231 Kconfig.it8801 Kconfig.lpflexcomm Kconfig.max20335 Kconfig.max22017 Kconfig.max31790 Kconfig.maxq10xx Kconfig.nct38xx Kconfig.npm1300 Kconfig.npm2100 Kconfig.npm6001 Kconfig.pf1550 Kconfig.tle9104
    ../../../../../zephyrproject/zephyr-iar/drivers/mipi_dbi/: Kconfig Kconfig.bitbang Kconfig.nxp_flexio_lcdif Kconfig.nxp_lcdic Kconfig.smartbond Kconfig.spi Kconfig.stm32_fmc
    ../../../../../zephyrproject/zephyr-iar/drivers/mipi_dsi/: Kconfig Kconfig.mcux Kconfig.renesas_ra Kconfig.stm32 Kconfig.test
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/devmux/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/ft8xx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/grove_lcd_rgb/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/mcux_flexio/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/nordic_vpr_launcher/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/nxp_s32_emios/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/pio_rpi_pico/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/renesas_ra_external_interrupt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/misc/timeaware_gpio/: Kconfig Kconfig.timeaware_gpio_intel
    ../../../../../zephyrproject/zephyr-iar/drivers/mm/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/modem/: Kconfig Kconfig.at_shell Kconfig.cellular Kconfig.hl7800 Kconfig.quectel-bg9x Kconfig.simcom-sim7080 Kconfig.ublox-sara-r4 Kconfig.wncm14a2a
    ../../../../../zephyrproject/zephyr-iar/drivers/mspi/: Kconfig Kconfig.ambiq Kconfig.dw Kconfig.mspi_emul
    ../../../../../zephyrproject/zephyr-iar/drivers/net/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/pcie/controller/: Kconfig Kconfig.brcmstb
    ../../../../../zephyrproject/zephyr-iar/drivers/pcie/endpoint/: Kconfig Kconfig.iproc
    ../../../../../zephyrproject/zephyr-iar/drivers/pcie/host/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/peci/: Kconfig Kconfig.it8xxx2 Kconfig.npcx Kconfig.xec
    ../../../../../zephyrproject/zephyr-iar/drivers/pinctrl/renesas/ra/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/pinctrl/renesas/rcar/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/pinctrl/renesas/rz/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/pinctrl/renesas/smartbond/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/pm_cpu_ops/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/power_domain/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/ps2/: Kconfig Kconfig.npcx Kconfig.xec
    ../../../../../zephyrproject/zephyr-iar/drivers/ptp_clock/: Kconfig Kconfig.nxp_enet
    ../../../../../zephyrproject/zephyr-iar/drivers/pwm/: Kconfig Kconfig.b91 Kconfig.cc13xx_cc26xx_timer Kconfig.ene Kconfig.esp32 Kconfig.fake Kconfig.gd32 Kconfig.gecko Kconfig.ifx_cat1 Kconfig.imx Kconfig.intel_blinky Kconfig.it8801 Kconfig.it8xxx2 Kconfig.litex Kconfig.max31790 Kconfig.max32 Kconfig.mcux Kconfig.mcux_ctimer Kconfig.mcux_ftm Kconfig.mcux_pwt Kconfig.mcux_qtmr Kconfig.mcux_sctimer Kconfig.mcux_tpm Kconfig.npcx Kconfig.nrf_sw Kconfig.nrfx Kconfig.numaker Kconfig.nxp_flexio Kconfig.nxp_s32_emios Kconfig.pca9685 Kconfig.rcar Kconfig.renesas_ra Kconfig.renesas_rz Kconfig.rpi_pico Kconfig.rv32m1_tpm Kconfig.sam Kconfig.sam0 Kconfig.sam0_tc Kconfig.sifive Kconfig.siwx91x Kconfig.stm32 Kconfig.test Kconfig.xec Kconfig.xlnx Kconfig.xmc4xxx_ccu4 Kconfig.xmc4xxx_ccu8
    ../../../../../zephyrproject/zephyr-iar/drivers/regulator/: Kconfig Kconfig.adp5360 Kconfig.axp192 Kconfig.cp9314 Kconfig.da1469x Kconfig.fake Kconfig.fixed Kconfig.gpio Kconfig.max20335 Kconfig.mpm54304 Kconfig.npm1100 Kconfig.npm1300 Kconfig.npm2100 Kconfig.npm6001 Kconfig.nxp_vref Kconfig.pca9420 Kconfig.pf1550 Kconfig.rpi_pico
    ../../../../../zephyrproject/zephyr-iar/drivers/reset/: Kconfig Kconfig.aspeed Kconfig.gd32 Kconfig.intel_socfpga Kconfig.lpc_syscon Kconfig.mmio Kconfig.npcx Kconfig.numaker Kconfig.nxp_rstctl Kconfig.rpi_pico Kconfig.stm32
    ../../../../../zephyrproject/zephyr-iar/drivers/retained_mem/: Kconfig Kconfig.nrf Kconfig.zephyr
    ../../../../../zephyrproject/zephyr-iar/drivers/rtc/: Kconfig Kconfig.am1805 Kconfig.ambiq Kconfig.bq32002 Kconfig.ds1307 Kconfig.ds1337 Kconfig.ds3231 Kconfig.emul Kconfig.fake Kconfig.ifx_cat1 Kconfig.mc146818 Kconfig.numaker Kconfig.nxp_irtc Kconfig.pcf2123 Kconfig.pcf8523 Kconfig.pcf8563 Kconfig.rpi_pico Kconfig.rts5912 Kconfig.rv3028 Kconfig.rv8263 Kconfig.rv8803 Kconfig.rx8130ce Kconfig.sam Kconfig.sam0 Kconfig.smartbond Kconfig.stm32 Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/sdhc/: Kconfig Kconfig.ambiq Kconfig.esp32 Kconfig.ifx_cat1 Kconfig.imx Kconfig.intel Kconfig.max32 Kconfig.mcux_sdif Kconfig.rcar Kconfig.renesas_ra Kconfig.sam_hsmci Kconfig.sdhc_cdns Kconfig.spi
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/a01nyub/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/adi/adltc2990/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/adi/adt7310/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/adi/adt7420/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/adi/adxl345/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/adi/adxl362/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/adi/adxl367/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/adi/adxl372/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/adi/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/amd_sb_tsi/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/amg88xx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ams/ams_as5600/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ams/ams_iAQcore/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ams/ccs811/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ams/ens210/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ams/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ams/tcs3400/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ams/tmd2620/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ams/tsl2540/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ams/tsl2561/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ams/tsl2591/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/aosong/ags10/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/aosong/dht20/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/aosong/dht/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/aosong/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/apds9253/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/apds9306/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/apds9960/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/asahi_kasei/ak8975/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/asahi_kasei/akm09918c/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/asahi_kasei/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bma280/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bma4xx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmc150_magn/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bme280/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bme680/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmg160/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmi08x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmi160/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmi270/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmi323/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmm150/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmm350/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmp180/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmp388/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/bmp581/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/bosch/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/current_amp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ene_tach_kb1200/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ens160/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/espressif/esp32_temp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/espressif/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/espressif/pcnt_esp32/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/everlight/als_pt19/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/everlight/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/explorir_m/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/f75303/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/fcx_mldx5/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/grow_r502a/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/hc_sr04/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/honeywell/hmc5883l/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/honeywell/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/honeywell/mpr/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/honeywell/sm351lt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/hp206c/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/infineon/dps310/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/infineon/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/infineon/tle9104/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/infineon/xmc4xxx_temp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ist8310/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ite/ite_tach_it8xxx2/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ite/ite_vcmp_it8xxx2/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ite/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/jedec/jc42/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/jedec/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/: Kconfig Kconfig.sensor_clock Kconfig.trigger_template
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/liteon/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/liteon/ltr329/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/liteon/ltrf216a/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/lm35/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/lm75/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/lm77/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/ds18b20/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/ds3231/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/max17055/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/max17262/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/max30101/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/max31790/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/max31855/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/max31865/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/max31875/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/max44009/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/maxim/max6675/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/meas/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/meas/ms5607/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/meas/ms5837/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/melexis/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/melexis/mlx90394/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/memsic/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/memsic/mc3419/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/memsic/mmc56x3/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/mhz19b/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/microchip/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/microchip/mchp_tach_xec/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/microchip/mcp9600/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/microchip/mcp970x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/microchip/tcn75a/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nct75/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nordic/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nordic/npm1300_charger/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nordic/npm2100_vbat/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nordic/qdec_nrfx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nordic/temp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ntc_thermistor/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nuvoton/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nuvoton/nuvoton_adc_cmp_npcx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nuvoton/nuvoton_tach_npcx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/fxas21002/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/fxls8974/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/fxos8700/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/mcux_acmp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/mcux_lpcmp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/nxp_kinetis_temp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/nxp_tempmon/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/p3t1755/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/qdec_mcux/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/nxp/qdec_nxp_s32/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/pixart/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/pixart/paa3905/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/pixart/pat9136/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/pms7003/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/qdec_sam/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/realtek/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/realtek/rts5912/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/renesas/hs300x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/renesas/hs400x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/renesas/isl29035/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/renesas/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/rohm/bd8lb600fs/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/rohm/bh1750/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/rohm/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/rpi_pico_temp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/s11059/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/sbs_gauge/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/seeed/grove/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/seeed/hm330x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/seeed/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/sensirion/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/sensirion/scd4x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/sensirion/sgp40/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/sensirion/sht3xd/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/sensirion/sht4x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/sensirion/shtcx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/sensirion/sts4x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/silabs/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/silabs/si7006/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/silabs/si7055/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/silabs/si7060/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/silabs/si7210/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/hts221/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/i3g4250d/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/iis2dh/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/iis2dlpc/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/iis2iclx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/iis2mdc/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/iis328dq/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/iis3dhhc/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/ism330dhcx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lis2de12/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lis2dh/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lis2ds12/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lis2du12/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lis2dux12/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lis2dw12/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lis2mdl/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lis3mdl/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lps22hb/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lps22hh/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lps25hb/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lps2xdf/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lsm303dlhc_magn/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lsm6ds0/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lsm6dsl/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lsm6dso16is/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lsm6dso/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lsm6dsv16x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lsm9ds0_gyro/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lsm9ds0_mfd/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/lsm9ds1/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/qdec_stm32/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/stm32_digi_temp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/stm32_temp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/stm32_vbat/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/stm32_vref/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/stmemsc/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/stts22h/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/stts751/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/vl53l0x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/st/vl53l1x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/sx9500/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/tdk/icm42605/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/tdk/icm42688/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/tdk/icm42x70/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/tdk/icm45686/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/tdk/icp101xx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/tdk/icp201xx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/tdk/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/tdk/mpu6050/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/tdk/mpu9250/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/th02/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/bq274xx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/fdc2x1x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/ina219/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/ina226/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/ina23x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/ina3221/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/lm95234/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/opt3001/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/ti_hdc20xx/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/ti_hdc/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/tmag5170/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/tmag5273/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/tmp007/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/tmp1075/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/tmp108/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/tmp112/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/tmp114/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/tmp11x/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/ti/tmp435/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/tsic_xx6/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/veaa_x_3/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/vishay/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/vishay/vcnl36825t/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/vishay/vcnl4040/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/vishay/veml6031/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/vishay/veml7700/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/voltage_divider/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/wsen/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/wsen/wsen_hids_2525020210002/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/wsen/wsen_pads_2511020213301/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/wsen/wsen_pdus_25131308XXXXX/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/wsen/wsen_tids_2521020222501/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/sensor/xbr818/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/serial/: Kconfig Kconfig.altera Kconfig.altera_jtag Kconfig.apbuart Kconfig.b91 Kconfig.bcm2711 Kconfig.bt Kconfig.cc13xx_cc26xx Kconfig.cc23x0 Kconfig.cc32xx Kconfig.cdns Kconfig.cmsdk_apb Kconfig.efinix_sapphire Kconfig.emul Kconfig.ene Kconfig.esp32 Kconfig.gd32 Kconfig.gecko Kconfig.hostlink Kconfig.ifx_cat1 Kconfig.imx Kconfig.intel_lw Kconfig.it51xxx Kconfig.it8xxx2 Kconfig.leuart_gecko Kconfig.litex Kconfig.lpc11u6x Kconfig.max32 Kconfig.mcux Kconfig.mcux_flexcomm Kconfig.mcux_iuart Kconfig.mcux_lpsci Kconfig.mcux_lpuart Kconfig.mec5 Kconfig.miv Kconfig.msp432p4xx Kconfig.native_pty Kconfig.native_tty Kconfig.neorv32 Kconfig.npcx Kconfig.nrfx Kconfig.nrfx_uart_instance Kconfig.ns16550 Kconfig.numaker Kconfig.numicro Kconfig.nxp_s32 Kconfig.opentitan Kconfig.pl011 Kconfig.psoc6 Kconfig.ql_usbserialport_s3b Kconfig.rcar Kconfig.realtek_rts5912 Kconfig.renesas_ra Kconfig.renesas_ra8 Kconfig.renesas_rz Kconfig.rpi_pico Kconfig.rtt Kconfig.rv32m1_lpuart Kconfig.rzt2m Kconfig.sam0 Kconfig.sedi Kconfig.si32 Kconfig.sifive Kconfig.silabs_eusart Kconfig.silabs_usart Kconfig.smartbond Kconfig.stellaris Kconfig.stm32 Kconfig.sy1xx Kconfig.test Kconfig.uart_sam Kconfig.usart_sam Kconfig.wch_usart Kconfig.xec Kconfig.xen Kconfig.xlnx Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/sip_svc/: Kconfig Kconfig.sip_smc_agilex
    ../../../../../zephyrproject/zephyr-iar/drivers/smbus/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/spi/: Kconfig Kconfig.ambiq Kconfig.andes_atcspi200 Kconfig.b91 Kconfig.bitbang Kconfig.cc13xx_cc26xx Kconfig.cdns Kconfig.dw Kconfig.esp32 Kconfig.gd32 Kconfig.grlib_spimctrl Kconfig.ifx_cat1 Kconfig.it8xxx2 Kconfig.litex Kconfig.max32 Kconfig.mchp_mss Kconfig.mchp_mss_qspi Kconfig.mcux_dspi Kconfig.mcux_ecspi Kconfig.mcux_flexcomm Kconfig.mcux_flexio Kconfig.npcx Kconfig.nrfx Kconfig.numaker Kconfig.nxp_s32 Kconfig.oc_simple Kconfig.opentitan Kconfig.pl022 Kconfig.psoc6 Kconfig.pw Kconfig.renesas_ra Kconfig.renesas_ra8 Kconfig.rpi_pico Kconfig.rv32m1_lpspi Kconfig.sam Kconfig.sam0 Kconfig.sedi Kconfig.sifive Kconfig.silabs_eusart Kconfig.silabs_usart Kconfig.smartbond Kconfig.spi_emul Kconfig.stm32 Kconfig.test Kconfig.xec_qmspi Kconfig.xlnx Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/spi/spi_nxp_lpspi/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/stepper/adi_tmc/: Kconfig Kconfig.tmc22xx Kconfig.tmc50xx Kconfig.tmc_rampgen_template
    ../../../../../zephyrproject/zephyr-iar/drivers/stepper/allegro/: Kconfig Kconfig.a4979
    ../../../../../zephyrproject/zephyr-iar/drivers/stepper/: Kconfig Kconfig.fake Kconfig.gpio Kconfig.stepper_event_template
    ../../../../../zephyrproject/zephyr-iar/drivers/stepper/step_dir/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/stepper/ti/: Kconfig Kconfig.drv84xx
    ../../../../../zephyrproject/zephyr-iar/drivers/syscon/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/tee/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/tee/optee/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/usb/bc12/: Kconfig Kconfig.pi3usb9201
    ../../../../../zephyrproject/zephyr-iar/drivers/usb/common/nrf_usbd_common/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/usb/device/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/usb/udc/: Kconfig Kconfig.ambiq Kconfig.dwc2 Kconfig.it82xx2 Kconfig.kinetis Kconfig.max32 Kconfig.mcux Kconfig.nrf Kconfig.numaker Kconfig.renesas_ra Kconfig.rpi_pico Kconfig.skeleton Kconfig.smartbond Kconfig.stm32 Kconfig.virtual
    ../../../../../zephyrproject/zephyr-iar/drivers/usb/uhc/: Kconfig Kconfig.max3421e Kconfig.virtual
    ../../../../../zephyrproject/zephyr-iar/drivers/usb/uvb/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/usb_c/ppc/: Kconfig Kconfig.numaker Kconfig.nxp
    ../../../../../zephyrproject/zephyr-iar/drivers/usb_c/tcpc/: Kconfig Kconfig.tcpc_numaker Kconfig.tcpc_ps8xxx Kconfig.tcpc_rt1715 Kconfig.tcpc_stm32 Kconfig.tcpc_tcpci
    ../../../../../zephyrproject/zephyr-iar/drivers/usb_c/vbus/: Kconfig Kconfig.numaker Kconfig.usbc_vbus_adc Kconfig.usbc_vbus_tcpci
    ../../../../../zephyrproject/zephyr-iar/drivers/video/: Kconfig Kconfig.emul_imager Kconfig.emul_rx Kconfig.esp32_dvp Kconfig.gc2145 Kconfig.mcux_csi Kconfig.mcux_mipi_csi2rx Kconfig.mcux_sdma Kconfig.mt9m114 Kconfig.ov2640 Kconfig.ov5640 Kconfig.ov7670 Kconfig.ov7725 Kconfig.stm32_dcmi Kconfig.sw_generator
    ../../../../../zephyrproject/zephyr-iar/drivers/virtualization/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/w1/: Kconfig Kconfig.ds2477_85 Kconfig.ds2482-800 Kconfig.ds2484 Kconfig.ds2485 Kconfig.max32 Kconfig.test Kconfig.zephyr_gpio Kconfig.zephyr_serial
    ../../../../../zephyrproject/zephyr-iar/drivers/watchdog/: Kconfig Kconfig.ambiq Kconfig.andes_atcwdt200 Kconfig.cc13xx_cc26xx Kconfig.cc32xx Kconfig.cmsdk_apb Kconfig.dw Kconfig.ene Kconfig.esp32 Kconfig.gd32 Kconfig.gecko Kconfig.ifx_cat1 Kconfig.intel_adsp Kconfig.it51xxx Kconfig.it8xxx2 Kconfig.litex Kconfig.max32 Kconfig.mcux Kconfig.mcux_imx Kconfig.npcx Kconfig.npm1300 Kconfig.npm2100 Kconfig.npm6001 Kconfig.nrfx Kconfig.numaker Kconfig.nxp_fs26 Kconfig.nxp_s32 Kconfig.opentitan Kconfig.renesas_ra Kconfig.rpi_pico Kconfig.rts5912 Kconfig.sam Kconfig.sam0 Kconfig.sam4l Kconfig.shell Kconfig.sifive Kconfig.siwx91x Kconfig.smartbond Kconfig.stm32 Kconfig.tco Kconfig.ti_tps382x Kconfig.xec Kconfig.xlnx Kconfig.xmc4xxx
    ../../../../../zephyrproject/zephyr-iar/drivers/wifi/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/xen/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/dts/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/acpi/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/cpp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/libc/newlib/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/libc/picolibc/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/net_buf/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/open-amp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/os/zvfs/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/posix/shell/: Kconfig Kconfig.env Kconfig.uname
    ../../../../../zephyrproject/zephyr-iar/lib/runtime/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/lib/smf/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/canopennode/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_ambiq/: Kconfig Kconfig.components Kconfig.hal
    ../../../../../zephyrproject/zephyr-iar/modules/hal_nordic/nrfs/backends/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_nordic/nrfs/dvfs/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_nordic/nrfs/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_nordic/nrfx/: Kconfig Kconfig.logging
    ../../../../../zephyrproject/zephyr-iar/modules/hal_silabs/simplicity_sdk/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_st/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/hal_tdk/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/: Kconfig Kconfig.altera Kconfig.atmel Kconfig.chre Kconfig.cypress Kconfig.eos_s3 Kconfig.esp32 Kconfig.infineon Kconfig.intel Kconfig.libmetal Kconfig.mcuboot Kconfig.microchip Kconfig.nuvoton Kconfig.open-amp Kconfig.picolibc Kconfig.renesas_fsp Kconfig.rust Kconfig.simplelink Kconfig.sof Kconfig.stm32 Kconfig.syst Kconfig.telink Kconfig.tinycrypt Kconfig.vega Kconfig.wurthelektronik Kconfig.xtensa modules.cmake
    ../../../../../zephyrproject/zephyr-iar/modules/lz4/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/nanopb/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/nrf_wifi/bus/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/tflite-micro/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/modules/thrift/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/soc/adi/max32/: Kconfig Kconfig.defconfig Kconfig.defconfig.max32650 Kconfig.defconfig.max32655 Kconfig.defconfig.max32660 Kconfig.defconfig.max32662 Kconfig.defconfig.max32666 Kconfig.defconfig.max32670 Kconfig.defconfig.max32672 Kconfig.defconfig.max32675 Kconfig.defconfig.max32680 Kconfig.defconfig.max32690 Kconfig.defconfig.max78000 Kconfig.defconfig.max78002 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/altr/qemu_nios2/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/altr/zephyr_nios2f/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ambiq/apollo3x/: Kconfig Kconfig.defconfig Kconfig.defconfig.apollo3_blue Kconfig.defconfig.apollo3p_blue Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ambiq/apollo4x/: Kconfig Kconfig.defconfig Kconfig.defconfig.apollo4p Kconfig.defconfig.apollo4p_blue Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ambiq/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/amd/acp_6_0/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/andestech/ae350/: Kconfig Kconfig.defconfig Kconfig.defconfig.ae350 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/andestech/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/antmicro/myra/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/arm/beetle/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/arm/designstart/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/arm/fvp_aemv8a/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/arm/fvp_aemv8r/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/arm/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/arm/mps2/: Kconfig Kconfig.defconfig Kconfig.defconfig.an383 Kconfig.defconfig.an385 Kconfig.defconfig.an386 Kconfig.defconfig.an500 Kconfig.defconfig.an521 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/arm/mps3/: Kconfig Kconfig.defconfig Kconfig.defconfig.mps3_corstone300 Kconfig.defconfig.mps3_corstone310 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/arm/musca/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/arm/qemu_cortex_a53/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/arm/qemu_virt_arm64/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/aspeed/ast10x0/: Kconfig Kconfig.defconfig Kconfig.defconfig.ast1030 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/aspeed/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/samc20/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/samc21/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/samd20/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/samd21/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/samd51/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/same51/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/same53/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/same54/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/saml21/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/samr21/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/samr34/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/samr35/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam/common/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam/sam3x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam/sam4e/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam/sam4l/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam/sam4s/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam/samx7x/: Kconfig Kconfig.defconfig Kconfig.soc Kconfig.soc.same70 Kconfig.soc.samv71
    ../../../../../zephyrproject/zephyr-iar/soc/brcm/bcm2711/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/brcm/bcm2712/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/brcm/bcmvk/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/brcm/bcmvk/valkyrie/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/brcm/bcmvk/viper/: Kconfig Kconfig.defconfig Kconfig.defconfig.viper_bcm58402_a72 Kconfig.defconfig.viper_bcm58402_m7 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/cdns/dc233c/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/cdns/sample_controller32/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/cdns/xtensa_sample_controller/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/common/riscv-privileged/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/soc/efinix/sapphire/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ene/kb1200/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/espressif/common/: Kconfig Kconfig.amp Kconfig.console Kconfig.defconfig Kconfig.esptool Kconfig.flash Kconfig.spiram
    ../../../../../zephyrproject/zephyr-iar/soc/espressif/esp32/: Kconfig Kconfig.defconfig Kconfig.mac Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/espressif/esp32c2/: Kconfig Kconfig.defconfig Kconfig.mac Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/espressif/esp32c3/: Kconfig Kconfig.defconfig Kconfig.mac Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/espressif/esp32c6/: Kconfig Kconfig.defconfig Kconfig.mac Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/espressif/esp32s2/: Kconfig Kconfig.defconfig Kconfig.mac Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/espressif/esp32s3/: Kconfig Kconfig.defconfig Kconfig.mac Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/espressif/: Kconfig Kconfig.defconfig Kconfig.soc Kconfig.ulp
    ../../../../../zephyrproject/zephyr-iar/soc/gaisler/gr716a/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gaisler/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gaisler/leon3/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gd/gd32/gd32a50x/: Kconfig Kconfig.defconfig.gd32a503 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gd/gd32/gd32e10x/: Kconfig Kconfig.defconfig.gd32e103 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gd/gd32/gd32e50x/: Kconfig Kconfig.defconfig.gd32e507 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gd/gd32/gd32f3x0/: Kconfig Kconfig.defconfig.gd32f350 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gd/gd32/gd32f403/: Kconfig Kconfig.defconfig.gd32f403 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gd/gd32/gd32f4xx/: Kconfig Kconfig.defconfig.gd32f405 Kconfig.defconfig.gd32f407 Kconfig.defconfig.gd32f450 Kconfig.defconfig.gd32f470 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gd/gd32/gd32l23x/: Kconfig Kconfig.defconfig.gd32l233 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gd/gd32/gd32vf103/: Kconfig Kconfig.defconfig.gd32vf103 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/gd/gd32/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/infineon/cat1a/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/infineon/cat1b/cyw20829/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/infineon/cat1b/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/infineon/cat3/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/infineon/cat3/xmc4xxx/: Kconfig Kconfig.defconfig Kconfig.defconfig.xmc4500 Kconfig.defconfig.xmc4700 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/alder_lake/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/apollo_lake/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/atom/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/elkhart_lake/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_adsp/ace/: Kconfig Kconfig.defconfig.ace15_mtpm Kconfig.defconfig.ace20_lnl Kconfig.defconfig.ace30 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_adsp/cavs/: Kconfig Kconfig.defconfig.cavs_v25 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_adsp/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_ish/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_niosv/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_niosv/niosv/: Kconfig Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_socfpga/agilex5/: Kconfig Kconfig.defconfig.agilex5 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_socfpga/agilex/: Kconfig Kconfig.defconfig.agilex Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_socfpga/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_socfpga_std/cyclonev/: Kconfig Kconfig.defconfig.cyclonev Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_socfpga_std/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/lakemont/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/raptor_lake/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ite/ec/it51xxx/: Kconfig Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ite/ec/it8xxx2/: Kconfig Kconfig.defconfig.it81202bx Kconfig.defconfig.it81202cx Kconfig.defconfig.it81202dx Kconfig.defconfig.it81302bx Kconfig.defconfig.it81302cx Kconfig.defconfig.it81302dx Kconfig.defconfig.it82002aw Kconfig.defconfig.it82002bw Kconfig.defconfig.it82202ax Kconfig.defconfig.it82202bw Kconfig.defconfig.it82302ax Kconfig.defconfig.it82302bw Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ite/ec/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/litex/litex_vexriscv/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/lowrisc/opentitan/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/mediatek/mt8xxx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/microchip/mec/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/microchip/mec/mec15xx/: Kconfig Kconfig.defconfig.mec1501hsz Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/microchip/mec/mec172x/: Kconfig Kconfig.defconfig.mec172xnlj Kconfig.defconfig.mec172xnsz Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/microchip/mec/mec174x/: Kconfig Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/microchip/mec/mec175x/: Kconfig Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/microchip/mec/mech172x/: Kconfig Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/microchip/miv/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/microchip/miv/miv/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/microchip/miv/polarfire/: Kconfig Kconfig.defconfig Kconfig.defconfig.polarfire_u54 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/native/inf_clock/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/neorv32/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/common/: Kconfig Kconfig.defconfig Kconfig.peripherals
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/common/vpr/: Kconfig Kconfig.defconfig
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/nrf51/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/nrf52/: Kconfig Kconfig.defconfig Kconfig.defconfig.nrf52805_CAAA Kconfig.defconfig.nrf52810_QFAA Kconfig.defconfig.nrf52811_QFAA Kconfig.defconfig.nrf52820_QDAA Kconfig.defconfig.nrf52832_CIAA Kconfig.defconfig.nrf52832_QFAA Kconfig.defconfig.nrf52832_QFAB Kconfig.defconfig.nrf52833_QDAA Kconfig.defconfig.nrf52833_QIAA Kconfig.defconfig.nrf52840_QFAA Kconfig.defconfig.nrf52840_QIAA Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/nrf53/: Kconfig Kconfig.defconfig Kconfig.defconfig.nrf5340_CPUAPP_QKAA Kconfig.defconfig.nrf5340_CPUNET_QKAA Kconfig.soc Kconfig.sync_rtc Kconfig.sync_rtc_ipm
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/nrf54h/bicr/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/nrf54h/gpd/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/nrf54h/: Kconfig Kconfig.defconfig Kconfig.defconfig.nrf54h20_cpuapp Kconfig.defconfig.nrf54h20_cpuflpr Kconfig.defconfig.nrf54h20_cpuppr Kconfig.defconfig.nrf54h20_cpurad Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/nrf54l/: Kconfig Kconfig.defconfig Kconfig.defconfig.nrf54l09_enga_cpuapp Kconfig.defconfig.nrf54l09_enga_cpuflpr Kconfig.defconfig.nrf54l20_enga_cpuapp Kconfig.defconfig.nrf54l20_enga_cpuflpr Kconfig.defconfig.nrf54l_05_10_15_cpuapp Kconfig.defconfig.nrf54l_05_10_15_cpuflpr Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/nrf91/: Kconfig Kconfig.defconfig Kconfig.defconfig.nrf9131_LACA Kconfig.defconfig.nrf9151_LACA Kconfig.defconfig.nrf9160_SICA Kconfig.defconfig.nrf9161_LACA Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nordic/nrf92/: Kconfig Kconfig.defconfig Kconfig.defconfig.nrf9280_cpuapp Kconfig.defconfig.nrf9280_cpuppr Kconfig.defconfig.nrf9280_cpurad Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/npcm/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/npcm/npcm4/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/npcx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/npcx/npcx4/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/npcx/npcx7/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/npcx/npcx9/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/numaker/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/numaker/m2l31x/: Kconfig Kconfig.defconfig Kconfig.defconfig.m2l31xxx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/numaker/m46x/: Kconfig Kconfig.defconfig Kconfig.defconfig.m467 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/numaker/m55m1x/: Kconfig Kconfig.defconfig Kconfig.defconfig.m55m1xxx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/numicro/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nuvoton/numicro/m48x/: Kconfig Kconfig.defconfig Kconfig.defconfig.m487 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/imx6sx/: Kconfig Kconfig.defconfig Kconfig.defconfig.mcimx6x_m4 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/imx7d/: Kconfig Kconfig.defconfig Kconfig.defconfig.mcimx7d_m4 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/imx8/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/imx8m/: Kconfig Kconfig.defconfig Kconfig.defconfig.mimx8ml8_a53 Kconfig.defconfig.mimx8ml8_adsp Kconfig.defconfig.mimx8ml8_m7 Kconfig.defconfig.mimx8mm6_a53 Kconfig.defconfig.mimx8mm6_m4 Kconfig.defconfig.mimx8mn6_a53 Kconfig.defconfig.mimx8mq6_m4 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/imx8ulp/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/imx8x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/imx9/imx91/: Kconfig Kconfig.defconfig Kconfig.defconfig.mimx91 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/imx9/imx93/: Kconfig Kconfig.defconfig Kconfig.defconfig.mimx93.a55 Kconfig.defconfig.mimx93.m33 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/imx9/imx95/: Kconfig Kconfig.defconfig Kconfig.defconfig.mimx95.a55 Kconfig.defconfig.mimx95.m7 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/imx9/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imxrt/imxrt10xx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imxrt/imxrt118x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imxrt/imxrt11xx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imxrt/imxrt5xx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imxrt/imxrt6xx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imxrt/imxrt7xx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/imxrt/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/kinetis/k2x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/kinetis/k6x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/kinetis/k8x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/kinetis/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/kinetis/ke1xf/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/kinetis/ke1xz/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/kinetis/kl2x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/kinetis/kv5x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/kinetis/kwx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/layerscape/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/layerscape/ls1046a/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/lpc/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/lpc/lpc11u6x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/lpc/lpc51u68/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/lpc/lpc54xxx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/lpc/lpc55xxx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/mcx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/mcx/mcxa/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/mcx/mcxc/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/mcx/mcxn/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/mcx/mcxw/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/rw/: Kconfig Kconfig.defconfig Kconfig.defconfig.wifi Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/s32/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/s32/s32k1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/s32/s32k3/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/s32/s32ze/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/oct/osd32mp15x/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/openhwgroup/cva6/cv32a6/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/openhwgroup/cva6/cv64a6/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/openhwgroup/cva6/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/openisa/rv32m1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/qemu/malta/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/qemu/virt_riscv/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/qemu/virt_riscv/qemu_virt_riscv32/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/qemu/virt_riscv/qemu_virt_riscv32e/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/qemu/virt_riscv/qemu_virt_riscv64/: Kconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/quicklogic/eos_s3/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/raspberrypi/rpi_pico/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/raspberrypi/rpi_pico/rp2040/: Kconfig Kconfig.defconfig Kconfig.defconfig.rp2040 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/raspberrypi/rpi_pico/rp2350/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/realtek/ec/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/realtek/ec/rts5912/: Kconfig Kconfig.defconfig.rts5912 Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra2a1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra2l1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra4e1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra4e2/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra4l1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra4m1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra4m2/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra4m3/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra4w1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra6e1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra6e2/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra6m1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra6m2/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra6m3/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra6m4/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra6m5/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra8d1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra8m1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/ra/ra8t1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rcar/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rcar/rcar_gen3/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rcar/rcar_gen4/: Kconfig Kconfig.defconfig Kconfig.defconfig.r8a779f0 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rz/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rz/rza3ul/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rz/rzg2l/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rz/rzg3s/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rz/rzn2l/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rz/rzt2l/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rz/rzt2m/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/rz/rzv2l/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/smartbond/da1469x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renesas/smartbond/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renode/cortex_r8_virtual/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/renode/riscv_virtual/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/rockchip/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/rockchip/rk3399/: Kconfig Kconfig.defconfig Kconfig.defconfig.rk3399 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/rockchip/rk35/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/rockchip/rk35/rk3568/: Kconfig Kconfig.defconfig Kconfig.defconfig.rk3568 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/rockchip/rk35/rk3588s/: Kconfig Kconfig.defconfig Kconfig.defconfig.rk3588s Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/sensry/ganymed/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/sensry/ganymed/sy1xx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/sensry/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/sifive/sifive_freedom/fe300/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/sifive/sifive_freedom/fu500/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/sifive/sifive_freedom/fu700/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/sifive/sifive_freedom/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s0/efm32hg/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s0/efm32wg/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s0/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s1/efm32gg11b/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s1/efm32gg12b/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s1/efm32jg12b/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s1/efm32pg12b/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s1/efm32pg1b/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s1/efr32bg13p/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s1/efr32fg13p/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s1/efr32fg1p/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s1/efr32mg12p/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s1/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s2/efr32bg22/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s2/efr32bg27/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s2/efr32mg21/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s2/efr32mg24/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s2/efr32zg23/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s2/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_s2/xg29/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_sim3/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_sim3/sim3u/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_siwx91x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/arc_iot/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/emsdp/: Kconfig Kconfig.defconfig Kconfig.defconfig.em11d Kconfig.defconfig.em4 Kconfig.defconfig.em5d Kconfig.defconfig.em6 Kconfig.defconfig.em7d Kconfig.defconfig.em7d_esp Kconfig.defconfig.em9d Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/emsk/: Kconfig Kconfig.defconfig Kconfig.defconfig.em11d Kconfig.defconfig.em7d Kconfig.defconfig.em9d Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/hsdk4xd/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/hsdk/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/nsim/arc_classic/em/: Kconfig Kconfig.defconfig Kconfig.defconfig.em Kconfig.defconfig.em11d Kconfig.defconfig.em7d_v22 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/nsim/arc_classic/hs/: Kconfig Kconfig.defconfig Kconfig.defconfig.hs Kconfig.defconfig.hs5x Kconfig.defconfig.hs5x_smp Kconfig.defconfig.hs6x Kconfig.defconfig.hs6x_smp Kconfig.defconfig.hs_mpuv6 Kconfig.defconfig.hs_smp Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/nsim/arc_classic/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/nsim/arc_classic/sem/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/nsim/arc_classic/vpx5/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/nsim/arc_v/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/nsim/arc_v/rmx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/snps/qemu_arc/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32c0x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32c011xx Kconfig.defconfig.stm32c031xx Kconfig.defconfig.stm32c071xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32f0x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32f030x4 Kconfig.defconfig.stm32f030x6 Kconfig.defconfig.stm32f030x8 Kconfig.defconfig.stm32f030xc Kconfig.defconfig.stm32f031x6 Kconfig.defconfig.stm32f042x6 Kconfig.defconfig.stm32f051x8 Kconfig.defconfig.stm32f070xb Kconfig.defconfig.stm32f072xx Kconfig.defconfig.stm32f091xc Kconfig.defconfig.stm32f098xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32f1x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32f100xx Kconfig.defconfig.stm32f103xx Kconfig.defconfig.stm32f105xx Kconfig.defconfig.stm32f107xc Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32f2x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32f205xx Kconfig.defconfig.stm32f207xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32f3x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32f302x8 Kconfig.defconfig.stm32f302xc Kconfig.defconfig.stm32f303x(b-c) Kconfig.defconfig.stm32f303x8 Kconfig.defconfig.stm32f303xe Kconfig.defconfig.stm32f334x8 Kconfig.defconfig.stm32f373xc Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32f7x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32f722xx Kconfig.defconfig.stm32f723xx Kconfig.defconfig.stm32f745xx Kconfig.defconfig.stm32f746xx Kconfig.defconfig.stm32f750xx Kconfig.defconfig.stm32f756xx Kconfig.defconfig.stm32f765xx Kconfig.defconfig.stm32f767xx Kconfig.defconfig.stm32f769xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32g0x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32g030xx Kconfig.defconfig.stm32g031xx Kconfig.defconfig.stm32g041xx Kconfig.defconfig.stm32g050xx Kconfig.defconfig.stm32g051xx Kconfig.defconfig.stm32g061xx Kconfig.defconfig.stm32g070xx Kconfig.defconfig.stm32g071xx Kconfig.defconfig.stm32g081xx Kconfig.defconfig.stm32g0b0xx Kconfig.defconfig.stm32g0b1xx Kconfig.defconfig.stm32g0c1xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32g4x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32g431xx Kconfig.defconfig.stm32g441xx Kconfig.defconfig.stm32g473xx Kconfig.defconfig.stm32g474xx Kconfig.defconfig.stm32g483xx Kconfig.defconfig.stm32g484xx Kconfig.defconfig.stm32g491xx Kconfig.defconfig.stm32g4a1xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32h5x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32h503xx Kconfig.defconfig.stm32h533xx Kconfig.defconfig.stm32h562xx Kconfig.defconfig.stm32h563xx Kconfig.defconfig.stm32h573xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32h7rsx/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32h7r3xx Kconfig.defconfig.stm32h7r7xx Kconfig.defconfig.stm32h7s3xx Kconfig.defconfig.stm32h7s7xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32h7x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32h723xx Kconfig.defconfig.stm32h725xx Kconfig.defconfig.stm32h730xx Kconfig.defconfig.stm32h735xx Kconfig.defconfig.stm32h743xx Kconfig.defconfig.stm32h745xx Kconfig.defconfig.stm32h747xx Kconfig.defconfig.stm32h750xx Kconfig.defconfig.stm32h753xx Kconfig.defconfig.stm32h755xx Kconfig.defconfig.stm32h757xx Kconfig.defconfig.stm32h7a3xx Kconfig.defconfig.stm32h7b0xx Kconfig.defconfig.stm32h7b3xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32l0x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32l010x4 Kconfig.defconfig.stm32l010x6 Kconfig.defconfig.stm32l010x8 Kconfig.defconfig.stm32l010xb Kconfig.defconfig.stm32l011xx Kconfig.defconfig.stm32l031xx Kconfig.defconfig.stm32l051xx Kconfig.defconfig.stm32l053xx Kconfig.defconfig.stm32l071xx Kconfig.defconfig.stm32l072xx Kconfig.defconfig.stm32l073xx Kconfig.defconfig.stm32l081xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32l1x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32l151xb Kconfig.defconfig.stm32l151xba Kconfig.defconfig.stm32l151xc Kconfig.defconfig.stm32l152xc Kconfig.defconfig.stm32l152xe Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32l4x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32l412xx Kconfig.defconfig.stm32l422xx Kconfig.defconfig.stm32l431xx Kconfig.defconfig.stm32l432xx Kconfig.defconfig.stm32l433xx Kconfig.defconfig.stm32l451xx Kconfig.defconfig.stm32l452xx Kconfig.defconfig.stm32l462xx Kconfig.defconfig.stm32l471xx Kconfig.defconfig.stm32l475xx Kconfig.defconfig.stm32l476xx Kconfig.defconfig.stm32l486xx Kconfig.defconfig.stm32l496xx Kconfig.defconfig.stm32l4a6xx Kconfig.defconfig.stm32l4p5xx Kconfig.defconfig.stm32l4q5xx Kconfig.defconfig.stm32l4r5xx Kconfig.defconfig.stm32l4r9xx Kconfig.defconfig.stm32l4s5xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32l5x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32l552xx Kconfig.defconfig.stm32l562xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32mp13x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32mp13_a7 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32mp1x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32mp15_m4 Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32n6x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32n657xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32u0x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32u031xx Kconfig.defconfig.stm32u073xx Kconfig.defconfig.stm32u083xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32u5x/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32u545xx Kconfig.defconfig.stm32u575xx Kconfig.defconfig.stm32u585xx Kconfig.defconfig.stm32u595xx Kconfig.defconfig.stm32u599xx Kconfig.defconfig.stm32u5a5xx Kconfig.defconfig.stm32u5a9xx Kconfig.defconfig.stm32u5g9xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32wb0x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32wbax/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32wba52xx Kconfig.defconfig.stm32wba55xx Kconfig.defconfig.stm32wba65xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32wbx/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32wb55xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32wlx/: Kconfig Kconfig.defconfig Kconfig.defconfig.stm32wl54xx Kconfig.defconfig.stm32wl55xx Kconfig.defconfig.stm32wle4xx Kconfig.defconfig.stm32wle5xx Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/starfive/jh71xx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/telink/tlsr/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/telink/tlsr/tlsr951x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ti/k3/am6x/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ti/k3/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ti/lm3s6965/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ti/simplelink/cc13x2_cc26x2/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ti/simplelink/cc13x2x7_cc26x2x7/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ti/simplelink/cc23x0/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ti/simplelink/cc32xx/: Kconfig Kconfig.defconfig Kconfig.defconfig.cc3220sf Kconfig.defconfig.cc3235sf Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ti/simplelink/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/ti/simplelink/msp432p4xx/: Kconfig Kconfig.defconfig Kconfig.defconfig.msp432p401r Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/wch/ch32v/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/wch/ch32v/qingke_v2a/: Kconfig Kconfig.defconfig Kconfig.defconfig.ch32v003 Kconfig.soc Kconfig.soc.ch32v003
    ../../../../../zephyrproject/zephyr-iar/soc/wch/ch32v/qingke_v4c/: Kconfig Kconfig.defconfig Kconfig.defconfig.ch32v208 Kconfig.soc Kconfig.soc.ch32v208
    ../../../../../zephyrproject/zephyr-iar/soc/xen/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/xlnx/versalnet/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/xlnx/zynq7000/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/xlnx/zynq7000/xc7zxxx/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/xlnx/zynq7000/xc7zxxxs/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/xlnx/zynqmp/: Kconfig Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/subsys/bindesc/: Kconfig Kconfig.build_time Kconfig.host_info Kconfig.version
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/audio/: Kconfig Kconfig.aics Kconfig.ascs Kconfig.bap Kconfig.cap Kconfig.ccp Kconfig.csip Kconfig.gmap Kconfig.has Kconfig.mcs Kconfig.mctl Kconfig.micp Kconfig.mpl Kconfig.pacs Kconfig.pbp Kconfig.tbs Kconfig.tmap Kconfig.vcp Kconfig.vocs
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/common/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/controller/coex/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/controller/: Kconfig Kconfig.df Kconfig.dtm Kconfig.ll_sw_split
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/crypto/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/host/classic/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/host/: Kconfig Kconfig.gatt Kconfig.l2cap
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/: Kconfig Kconfig.adv Kconfig.logging
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/lib/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/mesh/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/mesh/shell/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/services/: Kconfig Kconfig.cts Kconfig.dis Kconfig.hrs Kconfig.tps
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/services/ots/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/canbus/isotp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/console/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/dap/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/debug/coredump/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/debug/gdbstub/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/debug/symtab/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/debug/thread_analyzer/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/demand_paging/backing_store/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/demand_paging/eviction/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/demand_paging/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/dfu/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/disk/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/dsp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/emul/espi/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/emul/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/fs/ext2/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/fs/fcb/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/fs/nvs/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/fs/zms/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/input/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/ipc/ipc_service/backends/: Kconfig Kconfig.icbmsg Kconfig.icmsg_me Kconfig.rpmsg
    ../../../../../zephyrproject/zephyr-iar/subsys/ipc/ipc_service/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/ipc/ipc_service/lib/: Kconfig Kconfig.icmsg
    ../../../../../zephyrproject/zephyr-iar/subsys/ipc/rpmsg_service/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/jwt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/llext/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/lorawan/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/lorawan/nvm/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/lorawan/services/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mctp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/ec_host_cmd/backends/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/ec_host_cmd/: Kconfig Kconfig.logging
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/hawkbit/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/enum_mgmt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/fs_mgmt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/img_mgmt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/img_mgmt_client/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/os_mgmt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/os_mgmt_client/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/settings_mgmt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/shell_mgmt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/stat_mgmt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/grp/zephyr_basic/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/mgmt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/smp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/smp_client/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/mcumgr/transport/: Kconfig Kconfig.bluetooth Kconfig.dummy Kconfig.lorawan Kconfig.shell Kconfig.uart Kconfig.udp
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/osdp/: Kconfig Kconfig.cp Kconfig.pd
    ../../../../../zephyrproject/zephyr-iar/subsys/mgmt/updatehub/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/modem/backends/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/modem/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/conn_mgr/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/ip/: Kconfig Kconfig.debug Kconfig.ipv4 Kconfig.ipv6 Kconfig.mgmt Kconfig.stack Kconfig.stats Kconfig.tcp
    ../../../../../zephyrproject/zephyr-iar/subsys/net/: Kconfig Kconfig.hostname Kconfig.template.log_config.net
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/canbus/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/dummy/any/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/dummy/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/ethernet/gptp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/ethernet/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/ethernet/lldp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/ieee802154/: Kconfig Kconfig.radio
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/openthread/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/ppp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/virtual/ipip/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/virtual/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/l2/wifi/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/capture/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/coap/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/config/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/dhcpv4/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/dhcpv6/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/dns/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/http/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/lwm2m/: Kconfig Kconfig.ipso Kconfig.ucifi
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/mqtt/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/mqtt_sn/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/prometheus/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/ptp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/sntp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/sockets/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/socks/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/tftp/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/tls_credentials/: Kconfig Kconfig.shell
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/trickle/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/websocket/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/wifi_credentials/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/lib/zperf/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/net/pkt_filter/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/portability/cmsis_rtos_v1/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/portability/cmsis_rtos_v2/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/profiling/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/profiling/perf/backends/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/profiling/perf/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/retention/: Kconfig Kconfig.blinfo
    ../../../../../zephyrproject/zephyr-iar/subsys/secure_storage/: Kconfig Kconfig.its_store Kconfig.its_transform
    ../../../../../zephyrproject/zephyr-iar/subsys/sensing/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/sensing/sensor/hinge_angle/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/sensing/sensor/phy_3d_sensor/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/settings/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/shell/: Kconfig Kconfig.template.shell_log_queue_size Kconfig.template.shell_log_queue_timeout
    ../../../../../zephyrproject/zephyr-iar/subsys/shell/modules/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/shell/modules/kernel_service/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/shell/modules/kernel_service/thread/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/sip_svc/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/storage/flash_map/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/storage/stream/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/testsuite/ztest/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/timing/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/tracing/sysview/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/device/class/audio/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/device/class/dfu/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/device/class/hid/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/device/class/: Kconfig Kconfig.bt Kconfig.cdc Kconfig.msc Kconfig.template.composite_device_number Kconfig.test
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/device/class/netusb/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/device/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/device_next/class/: Kconfig Kconfig.bt Kconfig.cdc_acm Kconfig.cdc_ecm Kconfig.cdc_ncm Kconfig.dfu Kconfig.hid Kconfig.loopback Kconfig.midi2 Kconfig.msc Kconfig.template.instances_count Kconfig.uac2
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/device_next/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/host/: Kconfig Kconfig.usbip
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/usb_c/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/subsys/zbus/: Kconfig
    ../../../../../zephyrproject/zephyr-iar/drivers/wifi/infineon/: Kconfig.airoc
    ../../../../../zephyrproject/zephyr-iar/drivers/dai/intel/alh/: Kconfig.alh
    ../../../../../zephyrproject/zephyr-iar/subsys/shell/backends/: Kconfig.backends
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/services/bas/: Kconfig.bas
    ../../../../../zephyrproject/zephyr-iar/subsys/usb/device_next/app/: Kconfig.cdc_acm_serial
    ../../../../../zephyrproject/zephyr-iar/boards/shields/adafruit_2_8_tft_touch_v2/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/adafruit_neopixel_grid_bff/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/adafruit_winc1500/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/arceli_eth_w5500/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/arduino_giga_display_shield/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/atmel_rf2xx/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/buydisplay_2_8_tft_touch_arduino/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/buydisplay_3_5_tft_touch_arduino/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/esp_8266/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/frdm_cr20a/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/g1120b0mipi/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/inventek_eswifi/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/lcd_par_s035/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/link_board_eth/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/lmp90100_evb/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/ls0xx_generic/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/mikroe_adc_click/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/mikroe_ble_tiny_click/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/mikroe_eth3_click/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/mikroe_eth_click/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/mikroe_wifi_bt_click/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/rk043fn02h_ct/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/rk043fn66hs_ctg/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/rk055hdmipi4m/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/rk055hdmipi4ma0/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/rtk7eka6m3b00001bu/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/rtkmipilcdb00000be/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/seeed_w5500/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/seeed_xiao_expansion_board/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/seeed_xiao_round_display/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/sparkfun_sara_r4/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/ssd1306/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/st7735r/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/st7789v_generic/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/st_b_lcd40_dsi1_mb1166/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/waveshare_epaper/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/waveshare_pico_lcd_1_14/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/waveshare_pico_oled_1_3/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/wnc_m14a2a/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/x_nucleo_53l0a1/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/x_nucleo_bnrg2a1/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/x_nucleo_eeprma2/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/x_nucleo_idb05a1/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/x_nucleo_wb05kn1/: Kconfig.defconfig Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/soc/infineon/cat1a/psoc6_01/: Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/infineon/cat1a/psoc6_02/: Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/infineon/cat1a/psoc6_03/: Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/infineon/cat1a/psoc6_04/: Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/infineon/cat1a/psoc6_legacy/: Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/mediatek/mt8xxx/mt8186/: Kconfig.defconfig
    ../../../../../zephyrproject/zephyr-iar/soc/mediatek/mt8xxx/mt8188/: Kconfig.defconfig
    ../../../../../zephyrproject/zephyr-iar/soc/mediatek/mt8xxx/mt8195/: Kconfig.defconfig
    ../../../../../zephyrproject/zephyr-iar/soc/mediatek/mt8xxx/mt8196/: Kconfig.defconfig
    ../../../../../zephyrproject/zephyr-iar/soc/silabs/silabs_siwx91x/siwg917/: Kconfig.defconfig Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_ish/intel_ish5/: Kconfig.defconfig.series Kconfig.soc
    ../../../../../zephyrproject/zephyr-iar/drivers/dai/intel/dmic/: Kconfig.dmic
    ../../../../../zephyrproject/zephyr-iar/drivers/dai/nxp/esai/: Kconfig.esai
    ../../../../../zephyrproject/zephyr-iar/drivers/wifi/esp32/: Kconfig.esp32
    ../../../../../zephyrproject/zephyr-iar/drivers/wifi/esp_at/: Kconfig.esp_at
    ../../../../../zephyrproject/zephyr-iar/drivers/wifi/eswifi/: Kconfig.eswifi
    ../../../../../zephyrproject/zephyr-iar/soc/nxp/common/: Kconfig.flexspi_xip Kconfig.nbu Kconfig.rom_loader Kconfig.xspi_xip
    ../../../../../zephyrproject/zephyr-iar/drivers/dai/intel/hda/: Kconfig.hda
    ../../../../../zephyrproject/modules/hal/intel/zephyr/subsys/logging/backends/: Kconfig.i2c
    ../../../../../zephyrproject/zephyr-iar/arch/x86/core/: Kconfig.ia32 Kconfig.intel64
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/services/ias/: Kconfig.ias
    ../../../../../zephyrproject/zephyr-iar/modules/hal_nxp/imx/: Kconfig.imx
    ../../../../../zephyrproject/zephyr-iar/modules/hal_nxp/mcux/: Kconfig.mcux
    ../../../../../zephyrproject/zephyr-iar/drivers/audio/mic_privacy/intel/: Kconfig.mic_privacy
    ../../../../../zephyrproject/zephyr-iar/drivers/dai/nxp/micfil/: Kconfig.micfil
    ../../../../../zephyrproject/zephyr-iar/drivers/wifi/nrf_wifi/: Kconfig.nrfwifi
    ../../../../../zephyrproject/zephyr-iar/subsys/bluetooth/services/nus/: Kconfig.nus
    ../../../../../zephyrproject/zephyr-iar/drivers/wifi/nxp/: Kconfig.nxp
    ../../../../../zephyrproject/zephyr-iar/modules/hal_nxp/s32/: Kconfig.nxp_s32
    ../../../../../zephyrproject/zephyr-iar/soc/intel/intel_ish/intel_ish5/pm/: Kconfig.pm
    ../../../../../zephyrproject/zephyr-iar/drivers/dai/nxp/sai/: Kconfig.sai
    ../../../../../zephyrproject/zephyr-iar/soc/atmel/sam0/common/: Kconfig.samd2x Kconfig.samd5x Kconfig.saml2x
    ../../../../../zephyrproject/zephyr-iar/boards/shields/abrobot_esp32c3_oled/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/adafruit_adalogger_featherwing/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/adafruit_aw9523/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/adafruit_data_logger/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/adafruit_pca9685/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/amg88xx/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/arduino_uno_click/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/boostxl_ulpsense/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/dac80508_evm/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/dvp_fpc24_mt9m114/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/eval_ad4052_ardz/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/eval_adxl362_ardz/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/eval_adxl372_ardz/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/frdm_kw41z/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/frdm_stbc_agm01/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/ftdi_vm800c/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/m5stack_core2_ext/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/max3421e/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/max7219/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/mcp2515/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/mikroe_accel13_click/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/mikroe_mcp2518fd_click/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/mikroe_weather_click/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/npm1100_ek/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/npm1300_ek/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/npm6001_ek/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/nrf7002eb/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/nrf7002ek/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/nxp_btb44_ov5640/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/p3t1755dp_ard_i2c/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/p3t1755dp_ard_i3c/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/pmod_acl/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/pmod_sd/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/renesas_us159_da14531evz/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/reyax_lora/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/rpi_pico_uno_flexypin/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/semtech_sx1262mb2das/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/semtech_sx1272mb2das/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/semtech_sx1276mb1mas/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/sparkfun_carrier_asset_tracker/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/st_b_cams_omv_mb1683/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/tcan4550evm/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/ti_bp_bassensorsmkii/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/v2c_daplink/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/waveshare_ups/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/weact_ov2640_cam_module/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/x_nucleo_iks01a1/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/x_nucleo_iks01a2/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/x_nucleo_iks01a3/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/x_nucleo_iks02a1/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/boards/shields/x_nucleo_iks4a1/: Kconfig.shield
    ../../../../../zephyrproject/zephyr-iar/drivers/wifi/simplelink/: Kconfig.simplelink
    ../../../../../zephyrproject/zephyr-iar/drivers/wifi/siwx91x/: Kconfig.siwx91x
    ../../../../../zephyrproject/zephyr-iar/drivers/dai/intel/ssp/: Kconfig.ssp
    ../../../../../zephyrproject/zephyr-iar/drivers/wifi/winc1500/: Kconfig.winc1500
    ../../../../../zephyrproject/zephyr-iar/cmake/linker_script/arm/: linker.cmake
    ../../../../../zephyrproject/zephyr-iar/cmake/linker/iar/: linker_flags.cmake target.cmake
    ../../../../../zephyrproject/zephyr-iar/cmake/linker/: linker_flags_template.cmake linker_libraries_template.cmake target_template.cmake
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/drivers/wifi/: nrf_wifi
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/bluetooth/services/: nus
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/display/: panel.h
    ../zephyr-project/: prj.conf
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/pwm/: pwm.h stm32_pwm.h
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/sensor/: qdec_stm32.h
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/pinctrl/: renesas silabs stm32-pinctrl-common.h stm32-pinctrl.h
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/drivers/firmware/: scmi
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/arm/cortex_a_r/: scripts
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/arm/cortex_m/: scripts
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/arm/cortex_r/: scripts
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/arch/x86/ia32/: scripts
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/clock/: silabs stm32_common_clocks.h stm32f427_clock.h stm32f4_clock.h
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/dma/: silabs stm32_dma.h
    ../../../../../zephyrproject/zephyr-iar/snippets/bt-ll-sw-split/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/cdc-acm-console/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/nordic-flpr-xip/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/nordic-flpr/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/nordic-log-stm-dict/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/nordic-log-stm/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/nordic-ppr-xip/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/nordic-ppr/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/nus-console/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/ram-console/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/rtt-console/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/rtt-tracing/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/serial-console/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/usbip-native-sim/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/wifi-ip/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/wifi-ipv4/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/wifi-ipv6/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/snippets/xen_dom0/: snippet.yml
    ../../../../../zephyrproject/zephyr-iar/scripts/: snippets.py
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/reset/: stm32-common.h stm32f2_4_7_reset.h
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/memory-controller/: stm32-fmc-sdram.h
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/dt-bindings/power/: stm32_pwr.h
    ../../../../../zephyrproject/zephyr-iar/dts/arm/st/f4/: stm32f4.dtsi stm32f401.dtsi stm32f405.dtsi stm32f407.dtsi stm32f427.dtsi stm32f429.dtsi stm32f429Xi.dtsi
    ../../../../../zephyrproject/modules/hal/stm32/dts/st/f4/: stm32f429iitx-pinctrl.dtsi
    ../../../../../zephyrproject/zephyr-iar/boards/shields/st_b_lcd40_dsi1_mb1166/boards/: stm32h747i_disco_stm32h747xx_m7.defconfig stm32h757i_eval_stm32h757xx_m7.defconfig
    ../../../../../zephyrproject/zephyr-iar/include/zephyr/drivers/i2c/: target
    ../../../../../zephyrproject/zephyr-iar/cmake/bintools/iar/: target.cmake target_bintools.cmake
    ../../../../../zephyrproject/zephyr-iar/cmake/linker/ld/: target_configure.cmake target_relocation.cmake
    ../../../../../zephyrproject/zephyr-iar/include/: zephyr
    ../../../../../../progs/zephyr-sdk-0.17.0/cmake/: Zephyr-sdkConfig.cmake Zephyr-sdkConfigVersion.cmake
    ../../../../../zephyrproject/zephyr-iar/share/zephyr-package/cmake/: zephyr_package_search.cmake ZephyrConfig.cmake ZephyrConfigVersion.cmake
  group CMakeFiles/boards
    ../zephyr-project/boards/: stm32f429ii_aca.overlay
  group drivers__adc [Library]/../../../../../zephyrproject/zephyr-iar/drivers/adc
    ../../../../../zephyrproject/zephyr-iar/drivers/adc/: adc_common.c adc_stm32.c
  group drivers__clock_control [Library]/../../../../../zephyrproject/zephyr-iar/drivers/clock_control
    ../../../../../zephyrproject/zephyr-iar/drivers/clock_control/: clock_stm32_ll_common.c clock_stm32f2_f4_f7.c
  group drivers__console [Library]/../../../../../zephyrproject/zephyr-iar/drivers/console
    ../../../../../zephyrproject/zephyr-iar/drivers/console/: semihost_console.c
  group drivers__gpio [Library]/../../../../../zephyrproject/zephyr-iar/drivers/gpio
    ../../../../../zephyrproject/zephyr-iar/drivers/gpio/: gpio_stm32.c
  group drivers__interrupt_controller [Library]/../../../../../zephyrproject/zephyr-iar/drivers/interrupt_controller
    ../../../../../zephyrproject/zephyr-iar/drivers/interrupt_controller/: intc_exti_stm32.c
  group drivers__pinctrl [Library]/../../../../../zephyrproject/zephyr-iar/drivers/pinctrl
    ../../../../../zephyrproject/zephyr-iar/drivers/pinctrl/: common.c pinctrl_stm32.c
  group drivers__timer [Library]/../../../../../zephyrproject/zephyr-iar/drivers/timer
    ../../../../../zephyrproject/zephyr-iar/drivers/timer/: cortex_m_systick.c sys_clock_init.c
  group kernel [Library]/../../../../../zephyrproject/zephyr-iar/kernel
    ../../../../../zephyrproject/zephyr-iar/kernel/: banner.c busy_wait.c condvar.c device.c dynamic_disabled.c errno.c fatal.c float.c idle.c init.c init_static.c kheap.c mailbox.c main_weak.c mem_slab.c mempool.c msg_q.c mutex.c pipe.c queue.c sched.c sem.c stack.c system_work_q.c thread.c timeout.c timer.c timeslicing.c version.c work.c xip.c
  group lib__libc__common [Library]/../../../../../zephyrproject/zephyr-iar/lib/libc/common/source/stdlib
    ../../../../../zephyrproject/zephyr-iar/lib/libc/common/source/stdlib/: abort.c malloc.c
  group lib__libc__common [Library]/../../../../../zephyrproject/zephyr-iar/lib/libc/common/source/string
    ../../../../../zephyrproject/zephyr-iar/lib/libc/common/source/string/: strnlen.c
  group lib__libc__common [Library]/../../../../../zephyrproject/zephyr-iar/lib/libc/common/source/time
    ../../../../../zephyrproject/zephyr-iar/lib/libc/common/source/time/: asctime.c ctime.c gmtime_r.c localtime_r_utc.c
  group lib__libc__minimal [Library]/../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/source/math
    ../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/source/math/: sqrt.c sqrtf.c
  group lib__libc__minimal [Library]/../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/source/stdlib
    ../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/source/stdlib/: atoi.c bsearch.c exit.c qsort.c strtol.c strtoll.c strtoul.c strtoull.c
  group lib__libc__minimal [Library]/../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/source/stdout
    ../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/source/stdout/: fprintf.c sprintf.c stdout_console.c
  group lib__libc__minimal [Library]/../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/source/string
    ../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/source/string/: strerror.c string.c strncasecmp.c strspn.c strstr.c
  group lib__libc__minimal [Library]/../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/source/time
    ../../../../../zephyrproject/zephyr-iar/lib/libc/minimal/source/time/: gmtime.c
  group offsets [Library]/../../../../../zephyrproject/zephyr-iar/arch/arm/core/offsets
    ../../../../../zephyrproject/zephyr-iar/arch/arm/core/offsets/: offsets.c
  group zephyr [Library]/../../../../../zephyrproject/zephyr-iar/lib/heap
    ../../../../../zephyrproject/zephyr-iar/lib/heap/: heap.c
  group zephyr [Library]/../../../../../zephyrproject/zephyr-iar/lib/os
    ../../../../../zephyrproject/zephyr-iar/lib/os/: assert.c cbprintf.c cbprintf_complete.c cbprintf_packaged.c printk.c reboot.c sem.c thread_entry.c
  group zephyr [Library]/../../../../../zephyrproject/zephyr-iar/lib/utils
    ../../../../../zephyrproject/zephyr-iar/lib/utils/: bitarray.c dec.c hex.c rb.c ring_buffer.c timeutil.c
  group zephyr [Library]/../../../../../zephyrproject/zephyr-iar/soc/st/stm32/common
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/common/: soc_config.c stm32cube_hal.c
  group zephyr [Library]/../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32f4x
    ../../../../../zephyrproject/zephyr-iar/soc/st/stm32/stm32f4x/: soc.c
  group zephyr [Library]/../../../../../zephyrproject/zephyr-iar/subsys/mem_mgmt
    ../../../../../zephyrproject/zephyr-iar/subsys/mem_mgmt/: mem_attr.c
  group zephyr [Library]/../../../../../zephyrproject/zephyr-iar/subsys/tracing
    ../../../../../zephyrproject/zephyr-iar/subsys/tracing/: tracing_none.c
  group zephyr [Library]/../workbench/build/zephyr/misc/generated
    build/zephyr/misc/generated/: configs.c
