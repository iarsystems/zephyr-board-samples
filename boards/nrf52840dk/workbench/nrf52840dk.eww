<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\nrf52840dk.ewp</path>
    </project>
    <batchBuild />
</workspace>
